<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.13'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>b_Gray_Decoder_BB</value></param>
<param><key>author</key><value>Homero Ortega</value></param>
<param><key>category</key><value>comdiguis</value></param>
<param><key>description</key><value>apply Gray Decoding to input byte signal. This block may be paired with b_Gray_Encoder_BB</value></param>
<param><key>generate_options</key><value>hb</value></param>
<param><key>title</key><value>b_Gray_Decoder_BB</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>cod_gray</value></param>
<param><key>value</key><value>digital.utils.gray_code.gray_code(M)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>cod_gray_inv</value></param>
<param><key>value</key><value>digital.mod_codes.invert_code(cod_gray)</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>M</value></param>
<param><key>label</key><value>Modulus</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>8</value></param>
</block>
<block>
<key>digital_map_bb</key>
<param><key>id</key><value>digital_map_bb_0</value></param>
<param><key>map</key><value>cod_gray_inv</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>pad_sink_1</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>label</key><value>out</value></param>
</block>
<block>
<key>pad_source</key>
<param><key>id</key><value>pad_source_0_0</value></param>
<param><key>label</key><value>in</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<connection><source_block_id>digital_map_bb_0</source_block_id><sink_block_id>pad_sink_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pad_source_0_0</source_block_id><sink_block_id>digital_map_bb_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
