<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.13'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>b_binary_bipolar_simple_source_f</value></param>
<param><key>author</key><value>Homero Ortega Boada. Universidad Industrial de Santader</value></param>
<param><key>category</key><value>comdiguis</value></param>
<param><key>description</key><value>Genera una senal binaria bipolar aleatoria tipo float</value></param>
<param><key>generate_options</key><value>hb</value></param>
<param><key>title</key><value>b_binary_bipolar_simple_source_f</value></param>
</block>
<block>
<key>E3TRadio_unipolar_to_bipolar_ff</key>
<param><key>id</key><value>E3TRadio_unipolar_to_bipolar_ff_0</value></param>
<param><key>Amp</key><value>1.</value></param>
</block>
<block>
<key>analog_random_source_x</key>
<param><key>id</key><value>analog_random_source_x_0</value></param>
<param><key>max</key><value>2</value></param>
<param><key>min</key><value>0</value></param>
<param><key>num_samps</key><value>1000000</value></param>
<param><key>type</key><value>int</value></param>
<param><key>repeat</key><value>True</value></param>
</block>
<block>
<key>blocks_int_to_float</key>
<param><key>id</key><value>blocks_int_to_float_0</value></param>
<param><key>scale</key><value>1</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>pad_sink_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>label</key><value>out</value></param>
</block>
<connection><source_block_id>E3TRadio_unipolar_to_bipolar_ff_0</source_block_id><sink_block_id>pad_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_random_source_x_0</source_block_id><sink_block_id>blocks_int_to_float_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_int_to_float_0</source_block_id><sink_block_id>E3TRadio_unipolar_to_bipolar_ff_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
