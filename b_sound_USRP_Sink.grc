<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.9'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>b_sound_USRP_Sink</value></param>
<param><key>author</key><value>Homero Ortega Boada. Universidad Industrial de Santander</value></param>
<param><key>category</key><value>comdiguis</value></param>
<param><key>description</key><value>Es algo parecido a un USRP Source pero en vez de usar una antena, usa la bocina de sonido del computador, en un rango de frecuencias entre 0 Hz y  22500 Hz para explotar al maximo las capacidades de audio que usualmente tienen los computadores. Las salidas que este bloque tiene son opcionales, para pruebas, pues la verdadera salida es el sonido que sale por la bocina. Parametros usados: samp_rate (Hz) - es la frecuencia de muestreo de la senal que recibe nuestro bloque; Fc (Hz) - es la frecuencia de la portadora; Gain Value - es la ganancia en dB del amplificador interno; B (Hz) ancho de banda del canal pasobandas.</value></param>
<param><key>generate_options</key><value>hb</value></param>
<param><key>title</key><value>b_sound_USRP_Sink</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>BW</value></param>
<param><key>value</key><value>B/2</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>Gain_volts</value></param>
<param><key>value</key><value>math.pow(10,Gain_dB/20.)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate_passband</value></param>
<param><key>value</key><value>44100</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>B</value></param>
<param><key>label</key><value>Bandwidth (Hz)</value></param>
<param><key>value</key><value>2000</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>Fc</value></param>
<param><key>label</key><value>Center Freq (Hz)</value></param>
<param><key>value</key><value>4000</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>Gain_dB</value></param>
<param><key>label</key><value>Gain Value (dB)</value></param>
<param><key>value</key><value>0.</value></param>
</block>
<block>
<key>audio_sink</key>
<param><key>id</key><value>audio_sink_0</value></param>
<param><key>samp_rate</key><value>samp_rate_passband</value></param>
</block>
<block>
<key>b_upconverter_cf</key>
<param><key>id</key><value>b_upconverter_cf_0</value></param>
<param><key>Fc</key><value>Fc</value></param>
<param><key>samp_rate</key><value>samp_rate_passband</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_0</value></param>
<param><key>const</key><value>Gain_volts</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0</value></param>
<param><key>import</key><value>import math</value></param>
</block>
<block>
<key>low_pass_filter</key>
<param><key>id</key><value>low_pass_filter_0</value></param>
<param><key>cutoff_freq</key><value>BW</value></param>
<param><key>decim</key><value>1</value></param>
<param><key>type</key><value>fir_filter_ccf</value></param>
<param><key>gain</key><value>1</value></param>
<param><key>samp_rate</key><value>samp_rate_passband</value></param>
<param><key>width</key><value>BW/16.</value></param>
<param><key>win</key><value>firdes.WIN_HAMMING</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>pad_sink_1</value></param>
<param><key>type</key><value>float</value></param>
<param><key>label</key><value>pasobandas</value></param>
<param><key>optional</key><value>True</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>pad_sink_1_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>label</key><value>bandabase a 44100 muestras por simbolo</value></param>
<param><key>optional</key><value>True</value></param>
</block>
<block>
<key>pad_source</key>
<param><key>id</key><value>pad_source_0</value></param>
<param><key>label</key><value>in</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>rational_resampler_xxx</key>
<param><key>id</key><value>rational_resampler_xxx_0</value></param>
<param><key>decim</key><value>samp_rate</value></param>
<param><key>interp</key><value>samp_rate_passband</value></param>
<param><key>taps</key><value></value></param>
<param><key>type</key><value>ccc</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>label</key><value>samp_rate (Hz)</value></param>
<param><key>value</key><value>2000</value></param>
</block>
<connection><source_block_id>b_upconverter_cf_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0</source_block_id><sink_block_id>audio_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0</source_block_id><sink_block_id>pad_sink_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>low_pass_filter_0</source_block_id><sink_block_id>b_upconverter_cf_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>low_pass_filter_0</source_block_id><sink_block_id>pad_sink_1_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pad_source_0</source_block_id><sink_block_id>rational_resampler_xxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rational_resampler_xxx_0</source_block_id><sink_block_id>low_pass_filter_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
