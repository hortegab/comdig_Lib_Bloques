<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.9'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>b_USRP_2_USRP</value></param>
<param><key>author</key><value>Homero Ortega Boada. Universidad Industrial de Santander</value></param>
<param><key>category</key><value>comdiguis</value></param>
<param><key>description</key><value>Este bloque es el simulador de un canal inalambrico que incluye 2 USRPs, uno en la parte transmisora y otro en la receptora. Se puede usar cuando no se tengan USRP fisicos a la mano. Parametros usados: samp_rate (Hz) es la frecuencia de muestreo de la señal que entra y la que sale de este bloque; Center freq (Hz) frecuencia central del canal inalambrico; Bandwidth  (Hz) ancho de banda pasobandas del canal inalambrico; ; Toffset (numero de muestras de offset) permtite programar un tiempo de retardo de la senal en propagacion; Foffset (Hz) permite programar una desviacion entre la frecuencia central usada en la transmision y la usada en la recepcion; Phoffset (Rad) permite programar una desviacion entre el angulo de la portadora usada en transmision y la usada en recepcion; Vruido (volt) nivel del ruido blanco; Katt (lineal) nivel de atenuacion que la senal transmitida sufre en el proceso de propagacion.</value></param>
<param><key>generate_options</key><value>hb</value></param>
<param><key>title</key><value>b_USRP_2_USRP</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>B</value></param>
<param><key>label</key><value>Bandwidth (Hz)</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>130000</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>Fc</value></param>
<param><key>label</key><value>Center Freq (Hz)</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>200000000</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>Foffset</value></param>
<param><key>label</key><value>Foffset</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>0.</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>Katt</value></param>
<param><key>label</key><value>Katt</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>10.</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>Phoffset</value></param>
<param><key>label</key><value>Phoffset</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>(numpy.pi)*2*random.random()</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>Toffset</value></param>
<param><key>label</key><value>Toffset</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>5</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>Vruido</value></param>
<param><key>label</key><value>Vruido</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>0.</value></param>
</block>
<block>
<key>analog_const_source_x</key>
<param><key>id</key><value>analog_const_source_x_1_0</value></param>
<param><key>const</key><value>cmath.exp(1j * Phoffset)</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>analog_noise_source_x</key>
<param><key>id</key><value>analog_noise_source_x_0</value></param>
<param><key>amp</key><value>Vruido</value></param>
<param><key>noise_type</key><value>analog.GR_GAUSSIAN</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>seed</key><value>42</value></param>
</block>
<block>
<key>analog_sig_source_x</key>
<param><key>id</key><value>analog_sig_source_x_0</value></param>
<param><key>amp</key><value>1</value></param>
<param><key>freq</key><value>Foffset</value></param>
<param><key>offset</key><value>0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>waveform</key><value>analog.GR_COS_WAVE</value></param>
</block>
<block>
<key>blocks_add_xx</key>
<param><key>id</key><value>blocks_add_xx_0</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_delay</key>
<param><key>id</key><value>blocks_delay_0</value></param>
<param><key>delay</key><value>Toffset</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_0</value></param>
<param><key>const</key><value>1./Katt+0j</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_multiply_xx</key>
<param><key>id</key><value>blocks_multiply_xx_0</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_multiply_xx</key>
<param><key>id</key><value>blocks_multiply_xx_0_0</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0_1</value></param>
<param><key>import</key><value>import cmath</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0_1_0</value></param>
<param><key>import</key><value>import numpy</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0_1_0_0</value></param>
<param><key>import</key><value>import random</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0_1_1</value></param>
<param><key>import</key><value>import math</value></param>
</block>
<block>
<key>low_pass_filter</key>
<param><key>id</key><value>low_pass_filter_0</value></param>
<param><key>cutoff_freq</key><value>B/2.</value></param>
<param><key>decim</key><value>1</value></param>
<param><key>type</key><value>fir_filter_ccf</value></param>
<param><key>gain</key><value>1</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>width</key><value>B/8.</value></param>
<param><key>win</key><value>firdes.WIN_HAMMING</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>pad_sink_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>label</key><value>out</value></param>
</block>
<block>
<key>pad_source</key>
<param><key>id</key><value>pad_source_0</value></param>
<param><key>label</key><value>in</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>label</key><value>samp_rate</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>100e6/512</value></param>
</block>
<connection><source_block_id>analog_const_source_x_1_0</source_block_id><sink_block_id>blocks_multiply_xx_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>analog_noise_source_x_0</source_block_id><sink_block_id>blocks_add_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_sig_source_x_0</source_block_id><sink_block_id>blocks_multiply_xx_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_add_xx_0</source_block_id><sink_block_id>pad_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_delay_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0</source_block_id><sink_block_id>low_pass_filter_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_xx_0</source_block_id><sink_block_id>blocks_multiply_xx_0_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_multiply_xx_0_0</source_block_id><sink_block_id>blocks_add_xx_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>low_pass_filter_0</source_block_id><sink_block_id>blocks_multiply_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pad_source_0</source_block_id><sink_block_id>blocks_delay_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
