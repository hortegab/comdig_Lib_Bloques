<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.9'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>b_ds_spreadspect_cc</value></param>
<param><key>author</key><value>Homero Ortega Boada. Universidad Industrial de Santander</value></param>
<param><key>category</key><value>comdiguis</value></param>
<param><key>description</key><value>multiplica la entrada por codigo para producir una senal en Direc Sequence Spread Spectrum (DSSS). El cuidado que hay que tener es que el Spreading Factor (SF) se cuadra desde afuera, para la cual la senal de la informacion debe entrar con un sobremuestreo SF. Los parametros usados son: codigo - es el codigo que se usara para producir la senal DSSS</value></param>
<param><key>generate_options</key><value>hb</value></param>
<param><key>title</key><value>b_ds_spreadspect_cc</value></param>
</block>
<block>
<key>E3TRadio_zero_order_hold2_cc</key>
<param><key>id</key><value>E3TRadio_zero_order_hold2_cc_0</value></param>
<param><key>k</key><value>SF</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>SF</value></param>
<param><key>label</key><value>SF</value></param>
<param><key>value</key><value>8</value></param>
</block>
<block>
<key>blocks_multiply_xx</key>
<param><key>id</key><value>blocks_multiply_xx_0</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_vector_source_x</key>
<param><key>id</key><value>blocks_vector_source_x_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>repeat</key><value>True</value></param>
<param><key>vector</key><value>codigo</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>codigo</value></param>
<param><key>label</key><value>codigo</value></param>
<param><key>value</key><value>(1,1,1,1,1,1,1,1)</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>pad_sink_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>label</key><value>out</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>pad_sink_0_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>label</key><value>cod</value></param>
<param><key>optional</key><value>True</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>pad_sink_0_0_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>label</key><value>info</value></param>
<param><key>optional</key><value>True</value></param>
</block>
<block>
<key>pad_source</key>
<param><key>id</key><value>pad_source_0</value></param>
<param><key>label</key><value>in</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<connection><source_block_id>E3TRadio_zero_order_hold2_cc_0</source_block_id><sink_block_id>blocks_multiply_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>E3TRadio_zero_order_hold2_cc_0</source_block_id><sink_block_id>pad_sink_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_xx_0</source_block_id><sink_block_id>pad_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_vector_source_x_0</source_block_id><sink_block_id>blocks_multiply_xx_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_vector_source_x_0</source_block_id><sink_block_id>pad_sink_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pad_source_0</source_block_id><sink_block_id>E3TRadio_zero_order_hold2_cc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
