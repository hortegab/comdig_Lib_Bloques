<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.9'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>b_binary_gen_vec</value></param>
<param><key>author</key><value>Homero Ortega Boada. Universidad Industrial de Santader</value></param>
<param><key>category</key><value>comdiguis</value></param>
<param><key>description</key><value>This is a binary vector generator. Its is useful to produce a paquet of bits that generates repeatly. The paquet of bits corresponds to the binary version of the parameter Vector. Examples for the parameter Vector are:   [100]  or  [101, 54, 12]. What the block does is to traslate the values of the vector to bits and then to type float</value></param>
<param><key>generate_options</key><value>hb</value></param>
<param><key>title</key><value>b_binary_vect_source_f</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>Vector</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value>0</value></param>
</block>
<block>
<key>blocks_char_to_float</key>
<param><key>id</key><value>blocks_char_to_float_0_0_0</value></param>
<param><key>scale</key><value>1</value></param>
</block>
<block>
<key>blocks_unpack_k_bits_bb</key>
<param><key>id</key><value>blocks_unpack_k_bits_bb_0_0</value></param>
<param><key>k</key><value>8</value></param>
</block>
<block>
<key>blocks_vector_source_x</key>
<param><key>id</key><value>blocks_vector_source_x_0</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>repeat</key><value>True</value></param>
<param><key>vector</key><value>Vector</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>pad_sink_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>label</key><value>out</value></param>
</block>
<connection><source_block_id>blocks_char_to_float_0_0_0</source_block_id><sink_block_id>pad_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_unpack_k_bits_bb_0_0</source_block_id><sink_block_id>blocks_char_to_float_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_vector_source_x_0</source_block_id><sink_block_id>blocks_unpack_k_bits_bb_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
