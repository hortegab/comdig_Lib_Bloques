<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.9'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>b_PSD_VRMS_2ways_c</value></param>
<param><key>author</key><value>Homero Ortega</value></param>
<param><key>category</key><value>comdiguis</value></param>
<param><key>generate_options</key><value>hb_qt_gui</value></param>
<param><key>title</key><value>b_PSD_VRMS_2ways_c</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>Amp</value></param>
<param><key>label</key><value>Amplitud</value></param>
<param><key>value</key><value>1</value></param>
</block>
<block>
<key>E3TRadio_vector_average_hob</key>
<param><key>id</key><value>E3TRadio_vector_average_hob_0</value></param>
<param><key>Nensayos</key><value>1000000000</value></param>
<param><key>N</key><value>N</value></param>
</block>
<block>
<key>E3TRadio_vector_average_hob</key>
<param><key>id</key><value>E3TRadio_vector_average_hob_0_0</value></param>
<param><key>Nensayos</key><value>1000000000</value></param>
<param><key>N</key><value>N</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>Ensayos</value></param>
<param><key>label</key><value>N_ensayos</value></param>
<param><key>value</key><value>1000000</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>N</value></param>
<param><key>label</key><value>N_FFT</value></param>
<param><key>value</key><value>1024</value></param>
</block>
<block>
<key>blocks_complex_to_mag</key>
<param><key>id</key><value>blocks_complex_to_mag_0</value></param>
<param><key>vlen</key><value>N</value></param>
</block>
<block>
<key>blocks_complex_to_mag</key>
<param><key>id</key><value>blocks_complex_to_mag_0_0</value></param>
<param><key>vlen</key><value>N</value></param>
</block>
<block>
<key>blocks_complex_to_mag</key>
<param><key>id</key><value>blocks_complex_to_mag_1</value></param>
</block>
<block>
<key>blocks_complex_to_mag</key>
<param><key>id</key><value>blocks_complex_to_mag_1_0</value></param>
</block>
<block>
<key>blocks_complex_to_mag_squared</key>
<param><key>id</key><value>blocks_complex_to_mag_squared_0</value></param>
<param><key>vlen</key><value>N</value></param>
</block>
<block>
<key>blocks_complex_to_mag_squared</key>
<param><key>id</key><value>blocks_complex_to_mag_squared_0_0</value></param>
<param><key>vlen</key><value>N</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_0</value></param>
<param><key>const</key><value>numpy.full(N,1./N)</value></param>
<param><key>type</key><value>float</value></param>
<param><key>vlen</key><value>N</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_0_0</value></param>
<param><key>const</key><value>numpy.full(N,1./(Ensayos*N))</value></param>
<param><key>type</key><value>float</value></param>
<param><key>vlen</key><value>N</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_0_0_0</value></param>
<param><key>const</key><value>numpy.full(N,1./(Ensayos*N))</value></param>
<param><key>type</key><value>float</value></param>
<param><key>vlen</key><value>N</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_0_1</value></param>
<param><key>const</key><value>numpy.full(N,1./N)</value></param>
<param><key>type</key><value>float</value></param>
<param><key>vlen</key><value>N</value></param>
</block>
<block>
<key>blocks_multiply_xx</key>
<param><key>id</key><value>blocks_multiply_xx_0_0</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_multiply_xx</key>
<param><key>id</key><value>blocks_multiply_xx_0_0_0</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_nlog10_ff</key>
<param><key>id</key><value>blocks_nlog10_ff_0_2</value></param>
<param><key>k</key><value>0</value></param>
<param><key>n</key><value>10</value></param>
</block>
<block>
<key>blocks_nlog10_ff</key>
<param><key>id</key><value>blocks_nlog10_ff_0_2_0</value></param>
<param><key>k</key><value>0</value></param>
<param><key>n</key><value>10</value></param>
</block>
<block>
<key>blocks_rms_xx</key>
<param><key>id</key><value>blocks_rms_xx_0_0</value></param>
<param><key>alpha</key><value>0.0001</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_rms_xx</key>
<param><key>id</key><value>blocks_rms_xx_0_0_0</value></param>
<param><key>alpha</key><value>0.0001</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_stream_to_vector</key>
<param><key>id</key><value>blocks_stream_to_vector_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>num_items</key><value>N</value></param>
</block>
<block>
<key>blocks_stream_to_vector</key>
<param><key>id</key><value>blocks_stream_to_vector_0_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>num_items</key><value>N</value></param>
</block>
<block>
<key>fft_vxx</key>
<param><key>id</key><value>fft_vxx_0</value></param>
<param><key>fft_size</key><value>N</value></param>
<param><key>forward</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>shift</key><value>True</value></param>
<param><key>window</key><value></value></param>
</block>
<block>
<key>fft_vxx</key>
<param><key>id</key><value>fft_vxx_0_0</value></param>
<param><key>fft_size</key><value>N</value></param>
<param><key>forward</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>shift</key><value>True</value></param>
<param><key>window</key><value></value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0</value></param>
<param><key>import</key><value>import numpy</value></param>
</block>
<block>
<key>qtgui_tab_widget</key>
<param><key>id</key><value>mainwidget3</value></param>
<param><key>label0</key><value>Espectro Dinamico en Volts/Hz</value></param>
<param><key>label1</key><value>Especto Dinamico en dB</value></param>
<param><key>label2</key><value>PSD (Watts/Hz)</value></param>
<param><key>label3</key><value>PSD en dB</value></param>
<param><key>label4</key><value>Senal en tiempo</value></param>
<param><key>label5</key><value>Constelacion</value></param>
<param><key>num_tabs</key><value>6</value></param>
</block>
<block>
<key>pad_source</key>
<param><key>id</key><value>pad_source_2</value></param>
<param><key>label</key><value>Tx</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>pad_source</key>
<param><key>id</key><value>pad_source_2_0</value></param>
<param><key>label</key><value>Rx</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>qtgui_const_sink_x</key>
<param><key>id</key><value>qtgui_const_sink_x_0</value></param>
<param><key>gui_hint</key><value>mainwidget3@5:0,0</value></param>
<param><key>name</key><value>"Tx"</value></param>
<param><key>size</key><value>1024</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>qtgui_const_sink_x</key>
<param><key>id</key><value>qtgui_const_sink_x_0_0</value></param>
<param><key>gui_hint</key><value>mainwidget3@5:0,1</value></param>
<param><key>style1</key><value>1</value></param>
<param><key>name</key><value>"Rx"</value></param>
<param><key>size</key><value>1024</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>qtgui_freq_sink_x</key>
<param><key>id</key><value>qtgui_freq_sink_x_0</value></param>
<param><key>bw</key><value>samp_rate_audio</value></param>
<param><key>fc</key><value>0</value></param>
<param><key>ctrlpanel</key><value>True</value></param>
<param><key>fftsize</key><value>1024</value></param>
<param><key>gui_hint</key><value>mainwidget3@1:0,0,1,3</value></param>
<param><key>label1</key><value>Tx</value></param>
<param><key>label2</key><value>Rx</value></param>
<param><key>nconnections</key><value>2</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
</block>
<block>
<key>qtgui_freq_sink_x</key>
<param><key>id</key><value>qtgui_freq_sink_x_0_0</value></param>
<param><key>average</key><value>0.05</value></param>
<param><key>bw</key><value>samp_rate_audio</value></param>
<param><key>fc</key><value>0</value></param>
<param><key>ctrlpanel</key><value>True</value></param>
<param><key>fftsize</key><value>1024</value></param>
<param><key>gui_hint</key><value>mainwidget3@3:0,0,1,3</value></param>
<param><key>label1</key><value>Tx</value></param>
<param><key>label2</key><value>Rx</value></param>
<param><key>nconnections</key><value>2</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
</block>
<block>
<key>qtgui_number_sink</key>
<param><key>id</key><value>qtgui_number_sink_0_0_0_1</value></param>
<param><key>gui_hint</key><value>mainwidget3@4: 1,2,1,1</value></param>
<param><key>graph_type</key><value>qtgui.NUM_GRAPH_NONE</value></param>
<param><key>type</key><value>float</value></param>
<param><key>label1</key><value>Tx. P (dB)</value></param>
<param><key>label2</key><value>Rx. P (dB)</value></param>
<param><key>name</key><value>"P (dB)"</value></param>
<param><key>nconnections</key><value>2</value></param>
</block>
<block>
<key>qtgui_number_sink</key>
<param><key>id</key><value>qtgui_number_sink_0_0_1</value></param>
<param><key>gui_hint</key><value>mainwidget3@4: 1,1,1,1</value></param>
<param><key>graph_type</key><value>qtgui.NUM_GRAPH_NONE</value></param>
<param><key>type</key><value>float</value></param>
<param><key>label1</key><value>Tx,P</value></param>
<param><key>label2</key><value>Rx.P</value></param>
<param><key>name</key><value>"P"</value></param>
<param><key>nconnections</key><value>2</value></param>
</block>
<block>
<key>qtgui_number_sink</key>
<param><key>id</key><value>qtgui_number_sink_0_1</value></param>
<param><key>gui_hint</key><value>mainwidget3@4: 1,0,1,1</value></param>
<param><key>graph_type</key><value>qtgui.NUM_GRAPH_NONE</value></param>
<param><key>type</key><value>float</value></param>
<param><key>label1</key><value>Tx.VRMS</value></param>
<param><key>label2</key><value>Rx.VRMS</value></param>
<param><key>name</key><value>"VRMS"</value></param>
<param><key>nconnections</key><value>2</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0</value></param>
<param><key>ctrlpanel</key><value>True</value></param>
<param><key>gui_hint</key><value>mainwidget3@4:0,0,1,3</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value>Tx.Re</value></param>
<param><key>marker1</key><value>0</value></param>
<param><key>color2</key><value>"red"</value></param>
<param><key>label2</key><value>Tx.Im</value></param>
<param><key>color3</key><value>"green"</value></param>
<param><key>label3</key><value>Rx.Re</value></param>
<param><key>color4</key><value>"black"</value></param>
<param><key>label4</key><value>Rx.Im</value></param>
<param><key>name</key><value>"Osciloscopio"</value></param>
<param><key>nconnections</key><value>2</value></param>
<param><key>size</key><value>32</value></param>
<param><key>srate</key><value>samp_rate_audio</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>ymax</key><value>Amp</value></param>
<param><key>ymin</key><value>-Amp</value></param>
</block>
<block>
<key>qtgui_vector_sink_f</key>
<param><key>id</key><value>qtgui_vector_sink_f_0</value></param>
<param><key>gui_hint</key><value>mainwidget3@2:0,0,1,1</value></param>
<param><key>label1</key><value>Tx</value></param>
<param><key>label2</key><value>Rx</value></param>
<param><key>name</key><value></value></param>
<param><key>nconnections</key><value>2</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>vlen</key><value>N</value></param>
<param><key>x_axis_label</key><value>"Frecuencia"</value></param>
<param><key>x_start</key><value>-samp_rate_audio/2</value></param>
<param><key>x_step</key><value>(samp_rate_audio-1)/N</value></param>
<param><key>x_units</key><value>"Hz"</value></param>
<param><key>ymax</key><value>5./Ensayos</value></param>
<param><key>ymin</key><value>-1./(4*Ensayos)</value></param>
<param><key>y_axis_label</key><value>"Amplitud (Watt/Hz)"</value></param>
<param><key>y_units</key><value>"Watt/Hz"</value></param>
</block>
<block>
<key>qtgui_vector_sink_f</key>
<param><key>id</key><value>qtgui_vector_sink_f_0_0</value></param>
<param><key>gui_hint</key><value>mainwidget3@0:0,0,1,1</value></param>
<param><key>label1</key><value>Tx</value></param>
<param><key>label2</key><value>Rx</value></param>
<param><key>name</key><value></value></param>
<param><key>nconnections</key><value>2</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>vlen</key><value>N</value></param>
<param><key>x_axis_label</key><value>"Frecuency"</value></param>
<param><key>x_start</key><value>-samp_rate_audio/2</value></param>
<param><key>x_step</key><value>(samp_rate_audio-1)/N</value></param>
<param><key>x_units</key><value>"Hz"</value></param>
<param><key>ymax</key><value>0.1</value></param>
<param><key>ymin</key><value>-0.01</value></param>
<param><key>y_axis_label</key><value>"Amplitud (V/Hz)"</value></param>
<param><key>y_units</key><value>"V"</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>samp_rate_audio</value></param>
<param><key>label</key><value>Fmuestreo</value></param>
<param><key>value</key><value>22000</value></param>
</block>
<connection><source_block_id>E3TRadio_vector_average_hob_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>E3TRadio_vector_average_hob_0_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_mag_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_mag_0_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_mag_1</source_block_id><sink_block_id>blocks_rms_xx_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_mag_1_0</source_block_id><sink_block_id>blocks_rms_xx_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_mag_squared_0</source_block_id><sink_block_id>E3TRadio_vector_average_hob_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_mag_squared_0_0</source_block_id><sink_block_id>E3TRadio_vector_average_hob_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0</source_block_id><sink_block_id>qtgui_vector_sink_f_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0_0</source_block_id><sink_block_id>qtgui_vector_sink_f_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0_0_0</source_block_id><sink_block_id>qtgui_vector_sink_f_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0_1</source_block_id><sink_block_id>qtgui_vector_sink_f_0_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_multiply_xx_0_0</source_block_id><sink_block_id>blocks_nlog10_ff_0_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_xx_0_0</source_block_id><sink_block_id>qtgui_number_sink_0_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_xx_0_0_0</source_block_id><sink_block_id>blocks_nlog10_ff_0_2_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_xx_0_0_0</source_block_id><sink_block_id>qtgui_number_sink_0_0_1</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_nlog10_ff_0_2</source_block_id><sink_block_id>qtgui_number_sink_0_0_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_nlog10_ff_0_2_0</source_block_id><sink_block_id>qtgui_number_sink_0_0_0_1</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_rms_xx_0_0</source_block_id><sink_block_id>blocks_multiply_xx_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_rms_xx_0_0</source_block_id><sink_block_id>blocks_multiply_xx_0_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_rms_xx_0_0</source_block_id><sink_block_id>qtgui_number_sink_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_rms_xx_0_0_0</source_block_id><sink_block_id>blocks_multiply_xx_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_rms_xx_0_0_0</source_block_id><sink_block_id>blocks_multiply_xx_0_0_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_rms_xx_0_0_0</source_block_id><sink_block_id>qtgui_number_sink_0_1</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_stream_to_vector_0</source_block_id><sink_block_id>fft_vxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_stream_to_vector_0_0</source_block_id><sink_block_id>fft_vxx_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fft_vxx_0</source_block_id><sink_block_id>blocks_complex_to_mag_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fft_vxx_0</source_block_id><sink_block_id>blocks_complex_to_mag_squared_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fft_vxx_0_0</source_block_id><sink_block_id>blocks_complex_to_mag_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fft_vxx_0_0</source_block_id><sink_block_id>blocks_complex_to_mag_squared_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pad_source_2</source_block_id><sink_block_id>blocks_complex_to_mag_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pad_source_2</source_block_id><sink_block_id>blocks_stream_to_vector_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pad_source_2</source_block_id><sink_block_id>qtgui_const_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pad_source_2</source_block_id><sink_block_id>qtgui_freq_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pad_source_2</source_block_id><sink_block_id>qtgui_freq_sink_x_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pad_source_2</source_block_id><sink_block_id>qtgui_time_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pad_source_2_0</source_block_id><sink_block_id>blocks_complex_to_mag_1_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pad_source_2_0</source_block_id><sink_block_id>blocks_stream_to_vector_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pad_source_2_0</source_block_id><sink_block_id>qtgui_const_sink_x_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pad_source_2_0</source_block_id><sink_block_id>qtgui_freq_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>pad_source_2_0</source_block_id><sink_block_id>qtgui_freq_sink_x_0_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>pad_source_2_0</source_block_id><sink_block_id>qtgui_time_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
</flow_graph>
