<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.13'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>b_sampler</value></param>
<param><key>author</key><value>Homero Ortega Boada. Universidad Industrial de Santander</value></param>
<param><key>category</key><value>comdiguis</value></param>
<param><key>description</key><value>Por una salida entrega la senal diezmada y por la otra muestreada. El diezmado se realiza  de la manera en que se explica el diezmado en el libro de Tratamiento de Senales y Sistemas de Oppenheim. En ese diezmado se igualan a cero periodicamente un grupo de muestras. El muestreo, que se entrega en la otra salida de este bloque es similar al diezmado, pero las muestras que se igualan a cero son anuladas, es decir, desaparecen de la senal. Por esa razon, la rata de muestreo de la senal diezmada es la misma de la que entra al bloque, pero la rata de muestreo de la senal muestreada es Sps veces menor.</value></param>
<param><key>generate_options</key><value>hb</value></param>
<param><key>title</key><value>b_sampler</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>DelayDiez</value></param>
<param><key>label</key><value>Retrazo</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>0</value></param>
</block>
<block>
<key>E3TRadio_diezma_ff</key>
<param><key>id</key><value>E3TRadio_diezma_ff_0</value></param>
<param><key>M</key><value>DelayDiez</value></param>
<param><key>N</key><value>Sps</value></param>
</block>
<block>
<key>E3TRadio_diezmoppenh3_ff</key>
<param><key>id</key><value>E3TRadio_diezmoppenh3_ff_0</value></param>
<param><key>M</key><value>DelayDiez</value></param>
<param><key>N</key><value>Sps</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>Sps</value></param>
<param><key>label</key><value>Samp per symb</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>64</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>pad_sink_1</value></param>
<param><key>type</key><value>float</value></param>
<param><key>label</key><value>out</value></param>
<param><key>optional</key><value>True</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>pad_sink_2</value></param>
<param><key>type</key><value>float</value></param>
<param><key>label</key><value>Diezmado</value></param>
<param><key>optional</key><value>True</value></param>
</block>
<block>
<key>pad_source</key>
<param><key>id</key><value>pad_source_0</value></param>
<param><key>label</key><value>in</value></param>
<param><key>type</key><value>float</value></param>
</block>
<connection><source_block_id>E3TRadio_diezma_ff_0</source_block_id><sink_block_id>pad_sink_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>E3TRadio_diezmoppenh3_ff_0</source_block_id><sink_block_id>E3TRadio_diezma_ff_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>E3TRadio_diezmoppenh3_ff_0</source_block_id><sink_block_id>pad_sink_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pad_source_0</source_block_id><sink_block_id>E3TRadio_diezmoppenh3_ff_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
