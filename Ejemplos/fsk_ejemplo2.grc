<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.9'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>top_block</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
<param><key>run</key><value>run_stop</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>BW</value></param>
<param><key>value</key><value>5000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>Rb</value></param>
<param><key>value</key><value>samp_rate/Sps</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>Sps</value></param>
<param><key>value</key><value>16</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>TimingDelay</value></param>
<param><key>value</key><value>0</value></param>
<param><key>gui_hint</key><value>0,1</value></param>
<param><key>label</key><value>Timing</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>1</value></param>
<param><key>stop</key><value>Sps-1</value></param>
<param><key>rangeType</key><value>int</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>f0</value></param>
<param><key>value</key><value>1.4*1000</value></param>
</block>
<block>
<key>variable_qtgui_check_box</key>
<param><key>id</key><value>run_stop</value></param>
<param><key>value</key><value>True</value></param>
<param><key>false</key><value>False</value></param>
<param><key>gui_hint</key><value>0,0,1,1</value></param>
<param><key>label</key><value>Inicial/Parar</value></param>
<param><key>true</key><value>True</value></param>
<param><key>type</key><value>int</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>16000</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>Tx_3_0_0_1_0</value></param>
<param><key>stream_id</key><value>R1d</value></param>
</block>
<block>
<key>b_Eye_Diagram_c</key>
<param><key>id</key><value>b_Eye_Diagram_c_0_0</value></param>
<param><key>AlphaLineas</key><value>0.5</value></param>
<param><key>gui_hint</key><value>canal@0:3,0,1,1</value></param>
<param><key>GrosorLineas</key><value>20</value></param>
<param><key>N_eyes</key><value>2</value></param>
<param><key>Samprate</key><value>samp_rate</value></param>
<param><key>Sps</key><value>Sps</value></param>
<param><key>Title</key><value>"Filtro de acoplamiento.Salida"</value></param>
<param><key>Ymax</key><value>0.7</value></param>
<param><key>Ymin</key><value>-0.7</value></param>
</block>
<block>
<key>b_binary_bipolar_source_f</key>
<param><key>id</key><value>b_binary_bipolar_source_f_0</value></param>
<param><key>Am</key><value>1.</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>Spb</key><value>1</value></param>
</block>
<block>
<key>b_downconverter_fc</key>
<param><key>id</key><value>b_downconverter_fc_0</value></param>
<param><key>BW</key><value>BW/4</value></param>
<param><key>Fc</key><value>f0</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
</block>
<block>
<key>b_fsk_fc</key>
<param><key>id</key><value>b_fsk_fc_0</value></param>
<param><key>BW</key><value>BW</value></param>
<param><key>Sps</key><value>Sps</value></param>
<param><key>f0</key><value>f0</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
</block>
<block>
<key>b_sampler_cc</key>
<param><key>id</key><value>b_sampler_cc_0_0</value></param>
<param><key>DelayDiez</key><value>TimingDelay</value></param>
<param><key>Sps</key><value>Sps</value></param>
</block>
<block>
<key>blocks_complex_to_imag</key>
<param><key>id</key><value>blocks_complex_to_imag_0</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>blocks_throttle_0</value></param>
<param><key>samples_per_second</key><value>samp_rate</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_vector_source_x</key>
<param><key>id</key><value>blocks_vector_source_x_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>repeat</key><value>True</value></param>
<param><key>vector</key><value>(1,-1,-1,1,-1,1,1)</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>e1_0_0_0_1_0_0_0_0_0_0_0_1</value></param>
<param><key>stream_id</key><value>R1d</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>e1_0_0_0_1_0_0_0_1_0</value></param>
<param><key>stream_id</key><value>R0.1</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0</value></param>
<param><key>import</key><value>import math</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0_0_0</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value></value></param>
<param><key>color2</key><value>"red"</value></param>
<param><key>label2</key><value></value></param>
<param><key>size</key><value>1024</value></param>
<param><key>srate</key><value>samp_rate</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0_0_0_0</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value></value></param>
<param><key>color2</key><value>"red"</value></param>
<param><key>label2</key><value></value></param>
<param><key>size</key><value>1024</value></param>
<param><key>srate</key><value>Rb</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>s1_1_0_1_0</value></param>
<param><key>stream_id</key><value>R0.1</value></param>
</block>
<connection><source_block_id>b_binary_bipolar_source_f_0</source_block_id><sink_block_id>b_fsk_fc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>b_downconverter_fc_0</source_block_id><sink_block_id>b_sampler_cc_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>b_downconverter_fc_0</source_block_id><sink_block_id>qtgui_time_sink_x_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>b_downconverter_fc_0</source_block_id><sink_block_id>s1_1_0_1_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>b_fsk_fc_0</source_block_id><sink_block_id>blocks_complex_to_imag_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>b_sampler_cc_0_0</source_block_id><sink_block_id>Tx_3_0_0_1_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>b_sampler_cc_0_0</source_block_id><sink_block_id>blocks_throttle_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_imag_0</source_block_id><sink_block_id>b_downconverter_fc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>qtgui_time_sink_x_0_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_vector_source_x_0</source_block_id><sink_block_id>b_fsk_fc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>e1_0_0_0_1_0_0_0_0_0_0_0_1</source_block_id><sink_block_id>b_Eye_Diagram_c_0_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>e1_0_0_0_1_0_0_0_1_0</source_block_id><sink_block_id>b_Eye_Diagram_c_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
