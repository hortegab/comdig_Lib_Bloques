<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.9'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>top_block</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
<param><key>run</key><value>run_stop</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>Center_Freq</value></param>
<param><key>value</key><value>1000000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>Rb</value></param>
<param><key>value</key><value>samp_rate/Sps</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>Sps</value></param>
<param><key>value</key><value>4</value></param>
</block>
<block>
<key>variable_qtgui_check_box</key>
<param><key>id</key><value>run_stop</value></param>
<param><key>value</key><value>True</value></param>
<param><key>false</key><value>False</value></param>
<param><key>gui_hint</key><value>0,0,1,1</value></param>
<param><key>label</key><value>Inicial/Parar</value></param>
<param><key>true</key><value>True</value></param>
<param><key>type</key><value>int</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>200000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate_o</value></param>
<param><key>value</key><value>(Center_Freq+samp_rate/2)*8</value></param>
</block>
<block>
<key>b_Mod_BPSK</key>
<param><key>id</key><value>b_Mod_BPSK_0</value></param>
<param><key>Sps</key><value>Sps</value></param>
</block>
<block>
<key>b_USRP_Sink_simul_f</key>
<param><key>id</key><value>b_USRP_Sink_simul_f_0</value></param>
<param><key>Bandwidth</key><value>0</value></param>
<param><key>Center_Freq</key><value>Center_Freq</value></param>
<param><key>Gain_Value_dB</key><value>0</value></param>
<param><key>samp_rate_i</key><value>samp_rate</value></param>
<param><key>samp_rate_o</key><value>samp_rate_o</value></param>
</block>
<block>
<key>b_USRP_Sourc_simul_f</key>
<param><key>id</key><value>b_USRP_Sourc_simul_f_0</value></param>
<param><key>Bandwidth</key><value>0</value></param>
<param><key>Center_Freq</key><value>Center_Freq</value></param>
<param><key>Gain_Value_dB</key><value>0</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>samp_rate_rf</key><value>samp_rate_o</value></param>
</block>
<block>
<key>b_binary_gen_rand</key>
<param><key>id</key><value>b_binary_gen_rand_0</value></param>
</block>
<block>
<key>qtgui_freq_sink_x</key>
<param><key>id</key><value>qtgui_freq_sink_x_0</value></param>
<param><key>average</key><value>0.05</value></param>
<param><key>bw</key><value>samp_rate</value></param>
<param><key>fc</key><value>0</value></param>
<param><key>fftsize</key><value>1024</value></param>
<param><key>label1</key><value>"Tx.EC"</value></param>
<param><key>label2</key><value>"Rx.EC"</value></param>
<param><key>name</key><value></value></param>
<param><key>nconnections</key><value>2</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
</block>
<block>
<key>qtgui_freq_sink_x</key>
<param><key>id</key><value>qtgui_freq_sink_x_0_0</value></param>
<param><key>average</key><value>0.05</value></param>
<param><key>bw</key><value>samp_rate_o</value></param>
<param><key>fc</key><value>0</value></param>
<param><key>fftsize</key><value>1024*8</value></param>
<param><key>name</key><value>"Tx.Paso bandas"</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>float</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
<param><key>ymin</key><value>-90</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value></value></param>
<param><key>name</key><value>"Tx. Pasobandas"</value></param>
<param><key>size</key><value>1024</value></param>
<param><key>srate</key><value>samp_rate_o</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_1</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value></value></param>
<param><key>color2</key><value>"red"</value></param>
<param><key>label2</key><value></value></param>
<param><key>name</key><value>"Rx.EC"</value></param>
<param><key>size</key><value>128</value></param>
<param><key>srate</key><value>samp_rate</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>ymax</key><value>1.5</value></param>
<param><key>ymin</key><value>-1.5</value></param>
</block>
<connection><source_block_id>b_Mod_BPSK_0</source_block_id><sink_block_id>b_USRP_Sink_simul_f_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>b_Mod_BPSK_0</source_block_id><sink_block_id>qtgui_freq_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>b_USRP_Sink_simul_f_0</source_block_id><sink_block_id>b_USRP_Sourc_simul_f_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>b_USRP_Sink_simul_f_0</source_block_id><sink_block_id>qtgui_freq_sink_x_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>b_USRP_Sink_simul_f_0</source_block_id><sink_block_id>qtgui_time_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>b_USRP_Sourc_simul_f_0</source_block_id><sink_block_id>qtgui_freq_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>b_USRP_Sourc_simul_f_0</source_block_id><sink_block_id>qtgui_time_sink_x_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>b_binary_gen_rand_0</source_block_id><sink_block_id>b_Mod_BPSK_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
