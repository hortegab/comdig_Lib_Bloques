<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.9'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>top_block</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>a0</value></param>
<param><key>value</key><value>1</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>a1</value></param>
<param><key>value</key><value>2</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>a2</value></param>
<param><key>value</key><value>3</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>a3</value></param>
<param><key>value</key><value>4</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>a4</value></param>
<param><key>value</key><value>5</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>a5</value></param>
<param><key>value</key><value>6</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>a6</value></param>
<param><key>value</key><value>7</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>a7</value></param>
<param><key>value</key><value>8</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>f0</value></param>
<param><key>value</key><value>0</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>f1</value></param>
<param><key>value</key><value>1000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>f2</value></param>
<param><key>value</key><value>2*f1</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>f3</value></param>
<param><key>value</key><value>3*f1</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>f4</value></param>
<param><key>value</key><value>4*f1</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>f5</value></param>
<param><key>value</key><value>5*f1</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>f6</value></param>
<param><key>value</key><value>6*f1</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>f7</value></param>
<param><key>value</key><value>7*f1</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>32000</value></param>
</block>
<block>
<key>analog_sig_source_x</key>
<param><key>id</key><value>analog_sig_source_x_0</value></param>
<param><key>amp</key><value>a0</value></param>
<param><key>freq</key><value>f0</value></param>
<param><key>offset</key><value>0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>waveform</key><value>analog.GR_COS_WAVE</value></param>
</block>
<block>
<key>analog_sig_source_x</key>
<param><key>id</key><value>analog_sig_source_x_0_0</value></param>
<param><key>amp</key><value>a1</value></param>
<param><key>freq</key><value>f1</value></param>
<param><key>offset</key><value>0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>waveform</key><value>analog.GR_COS_WAVE</value></param>
</block>
<block>
<key>analog_sig_source_x</key>
<param><key>id</key><value>analog_sig_source_x_0_0_0</value></param>
<param><key>amp</key><value>a2</value></param>
<param><key>freq</key><value>f2</value></param>
<param><key>offset</key><value>0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>waveform</key><value>analog.GR_COS_WAVE</value></param>
</block>
<block>
<key>analog_sig_source_x</key>
<param><key>id</key><value>analog_sig_source_x_0_0_0_0</value></param>
<param><key>amp</key><value>a3</value></param>
<param><key>freq</key><value>f3</value></param>
<param><key>offset</key><value>0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>waveform</key><value>analog.GR_COS_WAVE</value></param>
</block>
<block>
<key>analog_sig_source_x</key>
<param><key>id</key><value>analog_sig_source_x_0_0_0_0_0</value></param>
<param><key>amp</key><value>a4</value></param>
<param><key>freq</key><value>f4</value></param>
<param><key>offset</key><value>0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>waveform</key><value>analog.GR_COS_WAVE</value></param>
</block>
<block>
<key>analog_sig_source_x</key>
<param><key>id</key><value>analog_sig_source_x_0_0_0_1</value></param>
<param><key>amp</key><value>a7</value></param>
<param><key>freq</key><value>f7</value></param>
<param><key>offset</key><value>0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>waveform</key><value>analog.GR_COS_WAVE</value></param>
</block>
<block>
<key>analog_sig_source_x</key>
<param><key>id</key><value>analog_sig_source_x_0_0_1</value></param>
<param><key>amp</key><value>a6</value></param>
<param><key>freq</key><value>f6</value></param>
<param><key>offset</key><value>0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>waveform</key><value>analog.GR_COS_WAVE</value></param>
</block>
<block>
<key>analog_sig_source_x</key>
<param><key>id</key><value>analog_sig_source_x_0_1</value></param>
<param><key>amp</key><value>a5</value></param>
<param><key>freq</key><value>f5</value></param>
<param><key>offset</key><value>0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>waveform</key><value>analog.GR_COS_WAVE</value></param>
</block>
<block>
<key>b_selectorN</key>
<param><key>id</key><value>b_selectorN_0</value></param>
<param><key>o0</key><value>2</value></param>
<param><key>o1</key><value>1</value></param>
<param><key>o2</key><value>0</value></param>
<param><key>o3</key><value>3</value></param>
<param><key>o4</key><value>4</value></param>
<param><key>o5</key><value>5</value></param>
<param><key>o6</key><value>6</value></param>
<param><key>o7</key><value>7</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0</value></param>
<param><key>gui_hint</key><value>0,0</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value></value></param>
<param><key>color2</key><value>"red"</value></param>
<param><key>label2</key><value></value></param>
<param><key>color3</key><value>"green"</value></param>
<param><key>label3</key><value></value></param>
<param><key>color4</key><value>"black"</value></param>
<param><key>label4</key><value></value></param>
<param><key>color5</key><value>"cyan"</value></param>
<param><key>label5</key><value></value></param>
<param><key>color6</key><value>"magenta"</value></param>
<param><key>label6</key><value></value></param>
<param><key>color7</key><value>"yellow"</value></param>
<param><key>label7</key><value></value></param>
<param><key>color8</key><value>"dark red"</value></param>
<param><key>label8</key><value></value></param>
<param><key>nconnections</key><value>4</value></param>
<param><key>size</key><value>1024</value></param>
<param><key>srate</key><value>samp_rate</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>ymax</key><value>8.2</value></param>
<param><key>ymin</key><value>-8.2</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0_0</value></param>
<param><key>gui_hint</key><value>1,0</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value></value></param>
<param><key>color2</key><value>"red"</value></param>
<param><key>label2</key><value></value></param>
<param><key>color3</key><value>"green"</value></param>
<param><key>label3</key><value></value></param>
<param><key>color4</key><value>"black"</value></param>
<param><key>label4</key><value></value></param>
<param><key>color5</key><value>"cyan"</value></param>
<param><key>label5</key><value></value></param>
<param><key>color6</key><value>"magenta"</value></param>
<param><key>label6</key><value></value></param>
<param><key>color7</key><value>"yellow"</value></param>
<param><key>label7</key><value></value></param>
<param><key>color8</key><value>"dark red"</value></param>
<param><key>label8</key><value></value></param>
<param><key>nconnections</key><value>4</value></param>
<param><key>size</key><value>1024</value></param>
<param><key>srate</key><value>samp_rate</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>ymax</key><value>8.2</value></param>
<param><key>ymin</key><value>-8.2</value></param>
</block>
<connection><source_block_id>analog_sig_source_x_0</source_block_id><sink_block_id>b_selectorN_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_sig_source_x_0_0</source_block_id><sink_block_id>b_selectorN_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>analog_sig_source_x_0_0_0</source_block_id><sink_block_id>b_selectorN_0</sink_block_id><source_key>0</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>analog_sig_source_x_0_0_0_0</source_block_id><sink_block_id>b_selectorN_0</sink_block_id><source_key>0</source_key><sink_key>3</sink_key></connection>
<connection><source_block_id>analog_sig_source_x_0_0_0_0_0</source_block_id><sink_block_id>b_selectorN_0</sink_block_id><source_key>0</source_key><sink_key>4</sink_key></connection>
<connection><source_block_id>analog_sig_source_x_0_0_0_1</source_block_id><sink_block_id>b_selectorN_0</sink_block_id><source_key>0</source_key><sink_key>7</sink_key></connection>
<connection><source_block_id>analog_sig_source_x_0_0_1</source_block_id><sink_block_id>b_selectorN_0</sink_block_id><source_key>0</source_key><sink_key>6</sink_key></connection>
<connection><source_block_id>analog_sig_source_x_0_1</source_block_id><sink_block_id>b_selectorN_0</sink_block_id><source_key>0</source_key><sink_key>5</sink_key></connection>
<connection><source_block_id>b_selectorN_0</source_block_id><sink_block_id>qtgui_time_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>b_selectorN_0</source_block_id><sink_block_id>qtgui_time_sink_x_0</sink_block_id><source_key>1</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>b_selectorN_0</source_block_id><sink_block_id>qtgui_time_sink_x_0</sink_block_id><source_key>2</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>b_selectorN_0</source_block_id><sink_block_id>qtgui_time_sink_x_0</sink_block_id><source_key>3</source_key><sink_key>3</sink_key></connection>
<connection><source_block_id>b_selectorN_0</source_block_id><sink_block_id>qtgui_time_sink_x_0_0</sink_block_id><source_key>4</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>b_selectorN_0</source_block_id><sink_block_id>qtgui_time_sink_x_0_0</sink_block_id><source_key>5</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>b_selectorN_0</source_block_id><sink_block_id>qtgui_time_sink_x_0_0</sink_block_id><source_key>6</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>b_selectorN_0</source_block_id><sink_block_id>qtgui_time_sink_x_0_0</sink_block_id><source_key>7</source_key><sink_key>3</sink_key></connection>
</flow_graph>
