<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.13'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>b_BERTool_Channel_M</value></param>
<param><key>author</key><value>Mancipe Andres, Padilla Astrid, Castillo Jeyson </value></param>
<param><key>category</key><value>comdiguis</value></param>
<param><key>description</key><value>Este Bloque sirve a la vez como canal de Ruido Blanco Gausiano y como herramienta para calcular y grafica la curva de BER (Bit error Rate) o SER para M diferentes caso de modulacion digital. Parametros usados: N_snr - numero de puntos que tendra la curva de BER o SER; EsNomin: valor minimo de la relación Es/No; EsNomax: valor máximo de la relacion Es/No. Las señales de entrada son: in Tx  para los  simbolos transmitidos; in Rx  para los simbolos recibidos; in es la entrante envolvente compleja de la señal modulada. Las salidas del bloque son: out env que es la saliente envolvente compleja con la adicion de ruido AWGN; out ser que son los valores de BER o SER disponibles. IMPORTANTE: que la curva sea BER o sea SER lo define el tipo de senal que se tiene en in Tx y en in Rx, donde se tiene en cada caso una senal M-aria. Asi que si M=2, estamos enviando y recibiendo bits, luego obtenemos curva de BER, pero si M&gt;2 estamos hablando de curva de SER. </value></param>
<param><key>generate_options</key><value>hb_qt_gui</value></param>
<param><key>title</key><value>b_BERTool_Channel_M</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>B</value></param>
<param><key>label</key><value>B</value></param>
<param><key>value</key><value>128</value></param>
</block>
<block>
<key>E3TRadio_e_BERtool</key>
<param><key>id</key><value>E3TRadio_e_BERtool_0</value></param>
<param><key>N</key><value>N_snr</value></param>
</block>
<block>
<key>E3TRadio_e_BERtool</key>
<param><key>id</key><value>E3TRadio_e_BERtool_0_0</value></param>
<param><key>N</key><value>N_snr</value></param>
</block>
<block>
<key>E3TRadio_e_canal_BER</key>
<param><key>id</key><value>E3TRadio_e_canal_BER_0</value></param>
<param><key>B</key><value>B</value></param>
<param><key>EsN0max</key><value>EsN0max</value></param>
<param><key>EsN0min</key><value>EsN0min</value></param>
<param><key>N</key><value>N_snr</value></param>
<param><key>Rs</key><value>Rs</value></param>
</block>
<block>
<key>E3TRadio_e_canal_BER</key>
<param><key>id</key><value>E3TRadio_e_canal_BER_0_0</value></param>
<param><key>B</key><value>B</value></param>
<param><key>EsN0max</key><value>EsN0max</value></param>
<param><key>EsN0min</key><value>EsN0min</value></param>
<param><key>N</key><value>N_snr</value></param>
<param><key>Rs</key><value>Rs</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>EsN0max</value></param>
<param><key>label</key><value>EsN0max</value></param>
<param><key>value</key><value>20</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>EsN0min</value></param>
<param><key>label</key><value>EsN0min</value></param>
<param><key>value</key><value>0</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>N_snr</value></param>
<param><key>label</key><value>N_snr</value></param>
<param><key>value</key><value>128</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>Rs</value></param>
<param><key>label</key><value>Rs</value></param>
<param><key>value</key><value>125</value></param>
</block>
<block>
<key>blocks_nlog10_ff</key>
<param><key>id</key><value>blocks_nlog10_ff_0</value></param>
<param><key>k</key><value>0</value></param>
</block>
<block>
<key>blocks_nlog10_ff</key>
<param><key>id</key><value>blocks_nlog10_ff_0_0</value></param>
<param><key>k</key><value>0</value></param>
</block>
<block>
<key>blocks_stream_to_vector</key>
<param><key>id</key><value>blocks_stream_to_vector_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>num_items</key><value>N_snr</value></param>
</block>
<block>
<key>blocks_stream_to_vector</key>
<param><key>id</key><value>blocks_stream_to_vector_0_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>num_items</key><value>N_snr</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>pad_sink_0_0_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>label</key><value>out_env0</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>pad_sink_0_0_0_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>label</key><value>out_env1</value></param>
</block>
<block>
<key>pad_source</key>
<param><key>id</key><value>pad_source_0_0</value></param>
<param><key>label</key><value>in0</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>pad_source</key>
<param><key>id</key><value>pad_source_0_0_0</value></param>
<param><key>label</key><value>in_Tx</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>pad_source</key>
<param><key>id</key><value>pad_source_0_0_0_0</value></param>
<param><key>label</key><value>in_Rx0</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>pad_source</key>
<param><key>id</key><value>pad_source_0_0_0_0_0</value></param>
<param><key>label</key><value>in_Rx1</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>pad_source</key>
<param><key>id</key><value>pad_source_0_0_1</value></param>
<param><key>label</key><value>in1</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>qtgui_vector_sink_f</key>
<param><key>id</key><value>qtgui_vector_sink_f_0</value></param>
<param><key>label1</key><value>tipo_mod0</value></param>
<param><key>width1</key><value>6</value></param>
<param><key>alpha2</key><value>1</value></param>
<param><key>label2</key><value>tipo_mod1</value></param>
<param><key>width2</key><value>6</value></param>
<param><key>name</key><value>"Curva de SER"</value></param>
<param><key>nconnections</key><value>2</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>vlen</key><value>N_snr</value></param>
<param><key>x_axis_label</key><value>"Es/N0 [dB]"</value></param>
<param><key>x_start</key><value>EsN0min</value></param>
<param><key>x_step</key><value>(EsN0max-EsN0min)/float(N_snr)</value></param>
<param><key>x_units</key><value>"dB"</value></param>
<param><key>ymax</key><value>0</value></param>
<param><key>ymin</key><value>-2</value></param>
<param><key>y_axis_label</key><value>"10logPe"</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>tipo_mod0</value></param>
<param><key>label</key><value>tipo_mod0</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value>"QPSK"</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>tipo_mod1</value></param>
<param><key>label</key><value>tipo_mod1</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value>"8PSK"</value></param>
</block>
<connection><source_block_id>E3TRadio_e_BERtool_0</source_block_id><sink_block_id>blocks_nlog10_ff_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>E3TRadio_e_BERtool_0_0</source_block_id><sink_block_id>blocks_nlog10_ff_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>E3TRadio_e_canal_BER_0</source_block_id><sink_block_id>pad_sink_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>E3TRadio_e_canal_BER_0</source_block_id><sink_block_id>E3TRadio_e_BERtool_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>E3TRadio_e_canal_BER_0_0</source_block_id><sink_block_id>pad_sink_0_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>E3TRadio_e_canal_BER_0_0</source_block_id><sink_block_id>E3TRadio_e_BERtool_0_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_nlog10_ff_0</source_block_id><sink_block_id>blocks_stream_to_vector_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_nlog10_ff_0_0</source_block_id><sink_block_id>blocks_stream_to_vector_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_stream_to_vector_0</source_block_id><sink_block_id>qtgui_vector_sink_f_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_stream_to_vector_0_0</source_block_id><sink_block_id>qtgui_vector_sink_f_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>pad_source_0_0</source_block_id><sink_block_id>E3TRadio_e_canal_BER_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pad_source_0_0_0</source_block_id><sink_block_id>E3TRadio_e_BERtool_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>pad_source_0_0_0</source_block_id><sink_block_id>E3TRadio_e_BERtool_0_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>pad_source_0_0_0_0</source_block_id><sink_block_id>E3TRadio_e_BERtool_0</sink_block_id><source_key>0</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>pad_source_0_0_0_0_0</source_block_id><sink_block_id>E3TRadio_e_BERtool_0_0</sink_block_id><source_key>0</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>pad_source_0_0_1</source_block_id><sink_block_id>E3TRadio_e_canal_BER_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
