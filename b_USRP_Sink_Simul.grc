<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.9'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>b_USRP_Sink_simul_f</value></param>
<param><key>author</key><value>Homero Ortega Boada. Universidad Industrial de Santander</value></param>
<param><key>category</key><value>comdiguis</value></param>
<param><key>description</key><value>Es un simulador del bloque USRP_Sink con el hardware tipo USRP 2920. Entrega una senal pasobandas, con una frecuencia de muestreo que se calcula asi: samp_rate_o=(Center_Freq+samp_rate/2)*8</value></param>
<param><key>generate_options</key><value>hb</value></param>
<param><key>title</key><value>b_USRP_Sink_simul_f</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>Samp_Rate_o</value></param>
<param><key>value</key><value>(Center_Freq+Samp_Rate/2)*8</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>Bandwidth</value></param>
<param><key>label</key><value>Ch0: Bandwidth (Hz)</value></param>
<param><key>value</key><value>0</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>Center_Freq</value></param>
<param><key>label</key><value>Ch0: Center_Freq</value></param>
<param><key>value</key><value>50000000</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>Gain_Value_dB</value></param>
<param><key>label</key><value>Ch0: Gain_Value (dB)</value></param>
<param><key>value</key><value>0</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>Lo_que_falta</value></param>
<param><key>note</key><value>poner amplificador, poner rango dinamico</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>Samp_Rate</value></param>
<param><key>label</key><value>Samp Rate (Sps)</value></param>
<param><key>value</key><value>200000</value></param>
</block>
<block>
<key>b_upconverter_cf</key>
<param><key>id</key><value>b_upconverter_cf_0</value></param>
<param><key>Fc</key><value>Center_Freq</value></param>
<param><key>samp_rate</key><value>Samp_Rate_o</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>pad_sink_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>label</key><value>out</value></param>
</block>
<block>
<key>pad_source</key>
<param><key>id</key><value>pad_source_0</value></param>
<param><key>label</key><value>in</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>rational_resampler_xxx</key>
<param><key>id</key><value>rational_resampler_xxx_0</value></param>
<param><key>decim</key><value>Samp_Rate</value></param>
<param><key>interp</key><value>Samp_Rate_o</value></param>
<param><key>taps</key><value></value></param>
<param><key>type</key><value>ccc</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>samp_rate_o</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>label</key><value>samp_rate_o</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>50000000+200000</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>tag_name</value></param>
<param><key>label</key><value>TSB tag name</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value>"    "</value></param>
</block>
<connection><source_block_id>b_upconverter_cf_0</source_block_id><sink_block_id>pad_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pad_source_0</source_block_id><sink_block_id>rational_resampler_xxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rational_resampler_xxx_0</source_block_id><sink_block_id>b_upconverter_cf_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
