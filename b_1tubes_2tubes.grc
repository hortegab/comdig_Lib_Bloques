<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.9'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>b_1tubes_2tubes</value></param>
<param><key>author</key><value>Homero Ortega Boada</value></param>
<param><key>category</key><value>comdiguis</value></param>
<param><key>description</key><value>Usado para extraer dos chorros de datos de diferentes velocidades (dos tubos) en un solo gran tubo. N1 es el numero de espacios que ocupa en el gran tubo, el primer tubo. N2 es para el segunto tubo</value></param>
<param><key>generate_options</key><value>hb</value></param>
<param><key>title</key><value>b_1tubes_2tubes</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>N</value></param>
<param><key>value</key><value>8</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>N1</value></param>
<param><key>value</key><value>5</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>N2</value></param>
<param><key>value</key><value>3</value></param>
</block>
<block>
<key>blocks_stream_to_streams</key>
<param><key>id</key><value>blocks_stream_to_streams_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>num_streams</key><value>N1+N2</value></param>
</block>
<block>
<key>blocks_streams_to_stream</key>
<param><key>id</key><value>blocks_streams_to_stream_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>num_streams</key><value>N1</value></param>
</block>
<block>
<key>blocks_streams_to_stream</key>
<param><key>id</key><value>blocks_streams_to_stream_0_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>num_streams</key><value>N2</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>pad_sink_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>label</key><value>out1</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>pad_sink_1</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>label</key><value>out0</value></param>
</block>
<block>
<key>pad_source</key>
<param><key>id</key><value>pad_source_0</value></param>
<param><key>label</key><value>in</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<connection><source_block_id>blocks_stream_to_streams_0</source_block_id><sink_block_id>blocks_streams_to_stream_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_stream_to_streams_0</source_block_id><sink_block_id>blocks_streams_to_stream_0</sink_block_id><source_key>1</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_stream_to_streams_0</source_block_id><sink_block_id>blocks_streams_to_stream_0</sink_block_id><source_key>2</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>blocks_stream_to_streams_0</source_block_id><sink_block_id>blocks_streams_to_stream_0</sink_block_id><source_key>3</source_key><sink_key>3</sink_key></connection>
<connection><source_block_id>blocks_stream_to_streams_0</source_block_id><sink_block_id>blocks_streams_to_stream_0</sink_block_id><source_key>4</source_key><sink_key>4</sink_key></connection>
<connection><source_block_id>blocks_stream_to_streams_0</source_block_id><sink_block_id>blocks_streams_to_stream_0_0</sink_block_id><source_key>5</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_stream_to_streams_0</source_block_id><sink_block_id>blocks_streams_to_stream_0_0</sink_block_id><source_key>6</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_stream_to_streams_0</source_block_id><sink_block_id>blocks_streams_to_stream_0_0</sink_block_id><source_key>7</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>blocks_streams_to_stream_0</source_block_id><sink_block_id>pad_sink_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_streams_to_stream_0_0</source_block_id><sink_block_id>pad_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pad_source_0</source_block_id><sink_block_id>blocks_stream_to_streams_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
