<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.13'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>b_eye_timing2_f</value></param>
<param><key>author</key><value>Homero Ortega</value></param>
<param><key>category</key><value>comdiguis</value></param>
<param><key>description</key><value>permite visualizar el diagrama de ojo y el instante del timing. Parametros usados: N es el numero de muestras en el intervalo de tiempo a graficar, se recomienda que N=2*Sps, donde Sps es el numero de muestras por simbolo; samp_rate es la frecuencia de muestreo; Delay es el retraso que se le puede aplicar a la senal para centrar mejor el ojo</value></param>
<param><key>generate_options</key><value>hb</value></param>
<param><key>title</key><value>b_eye_timing2_f</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>N</value></param>
<param><key>value</key><value>64</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>Spsi</value></param>
<param><key>value</key><value>32</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>Delay</value></param>
<param><key>label</key><value>Delay</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>0</value></param>
</block>
<block>
<key>E3TRadio_diezmoppenh3_ff</key>
<param><key>id</key><value>E3TRadio_diezmoppenh3_ff_0</value></param>
<param><key>M</key><value>int((Timing-Sps/2)*Spsi/Sps)</value></param>
<param><key>N</key><value>Spsi</value></param>
</block>
<block>
<key>E3TRadio_vec_diagrama_ojo2_f</key>
<param><key>id</key><value>E3TRadio_vec_diagrama_ojo2_f_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>N</key><value>Spsi*2</value></param>
<param><key>samp_rate</key><value>samp_rate*Spsi/Sps</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>Nvol</value></param>
<param><key>label</key><value>N curvas</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>100</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>Sps</value></param>
<param><key>label</key><value>Sps</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>8</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>Timing</value></param>
<param><key>label</key><value>Timing</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>0</value></param>
</block>
<block>
<key>blocks_delay</key>
<param><key>id</key><value>blocks_delay_0</value></param>
<param><key>delay</key><value>Delay</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_stream_mux</key>
<param><key>id</key><value>blocks_stream_mux_0</value></param>
<param><key>lengths</key><value>Spsi*2, Spsi*2</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_stream_to_vector</key>
<param><key>id</key><value>blocks_stream_to_vector_0_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>num_items</key><value>N</value></param>
</block>
<block>
<key>epy_block</key>
<param><key>id</key><value>epy_block_0</value></param>
<param><key>_source_code</key><value>import numpy as np
from gnuradio import gr
import matplotlib.pyplot as plt

class vec_diagrama_ojo2_f(gr.sync_block):
    """
    Diagrama de ojo. Hecho por Homero Ortega Boada. Universida Industrial de Santander.
N: es el numero de muestras que ocupara el ojo, se recomienda que N=Sps*2, donde Sps es el numero de muestras por simbolo.
samp_rate: es la frecuencia de muestreo de la senal.
    """
    def __init__(self, N=64, samp_rate=32000, Ncurvas=100):
        gr.sync_block.__init__(self,
            name="e_vec_diagrama_ojo2_f",
            in_sig=[(np.float32, N)],
            out_sig=None)
        #########################################
        ##        Parametros                   ##
        #########################################
        self.Sps = N/2
        self.Tsamp=1./samp_rate
        Tb=self.Sps*self.Tsamp
        self.t = np.linspace(-Tb,Tb, 2*self.Sps)
        self.Ncurvas=Ncurvas
        self.contador=0

    def work(self, input_items, output_items):
        in0 = input_items[0] # in0 es un 2D array (como una matrix)
        s=in0[0]    # Esto traduce el 2D array a 1D array (a un vector)
        #plt.plot(self.t,s)             
        #plt.pause(self.Tsamp)
        if self.contador &lt; self.Ncurvas:
            plt.plot(self.t,s)
            plt.pause(self.Tsamp)
            self.contador += 1
        else:
            self.contador=0
            plt.clf()
        return len(input_items[0])
</value></param>
<param><key>N</key><value>N</value></param>
<param><key>Ncurvas</key><value>Nvol</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
</block>
<block>
<key>pad_source</key>
<param><key>id</key><value>pad_source_0</value></param>
<param><key>label</key><value>in</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>rational_resampler_xxx</key>
<param><key>id</key><value>rational_resampler_xxx_0</value></param>
<param><key>decim</key><value>Sps</value></param>
<param><key>interp</key><value>Spsi</value></param>
<param><key>taps</key><value></value></param>
<param><key>type</key><value>fff</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>label</key><value>samp_rate</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>32000</value></param>
</block>
<connection><source_block_id>E3TRadio_diezmoppenh3_ff_0</source_block_id><sink_block_id>blocks_stream_mux_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_delay_0</source_block_id><sink_block_id>rational_resampler_xxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_stream_mux_0</source_block_id><sink_block_id>blocks_stream_to_vector_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_stream_to_vector_0_0</source_block_id><sink_block_id>E3TRadio_vec_diagrama_ojo2_f_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_stream_to_vector_0_0</source_block_id><sink_block_id>epy_block_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pad_source_0</source_block_id><sink_block_id>blocks_delay_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rational_resampler_xxx_0</source_block_id><sink_block_id>E3TRadio_diezmoppenh3_ff_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rational_resampler_xxx_0</source_block_id><sink_block_id>blocks_stream_mux_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
