<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.9'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>b_PSD_VRMS_c</value></param>
<param><key>author</key><value>Homero Ortega</value></param>
<param><key>category</key><value>comdiguis</value></param>
<param><key>generate_options</key><value>hb_qt_gui</value></param>
<param><key>title</key><value>b_PSD_VRMS_c</value></param>
</block>
<block>
<key>E3TRadio_vector_average_hob</key>
<param><key>id</key><value>E3TRadio_vector_average_hob_0</value></param>
<param><key>Nensayos</key><value>1000000000</value></param>
<param><key>N</key><value>N</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>Ensayos</value></param>
<param><key>label</key><value>N_ensayos</value></param>
<param><key>value</key><value>1000000</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>Fc</value></param>
<param><key>label</key><value>Fc</value></param>
<param><key>value</key><value>10000</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>N</value></param>
<param><key>label</key><value>N_FFT</value></param>
<param><key>value</key><value>1024</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>Titulo</value></param>
<param><key>label</key><value>Titulo</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value></value></param>
</block>
<block>
<key>blocks_complex_to_mag</key>
<param><key>id</key><value>blocks_complex_to_mag_0</value></param>
<param><key>vlen</key><value>N</value></param>
</block>
<block>
<key>blocks_complex_to_mag_squared</key>
<param><key>id</key><value>blocks_complex_to_mag_squared_0</value></param>
<param><key>vlen</key><value>N</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_0</value></param>
<param><key>const</key><value>numpy.full(N,1./N)</value></param>
<param><key>type</key><value>float</value></param>
<param><key>vlen</key><value>N</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_0_0</value></param>
<param><key>const</key><value>numpy.full(N,1./(Ensayos*N))</value></param>
<param><key>type</key><value>float</value></param>
<param><key>vlen</key><value>N</value></param>
</block>
<block>
<key>blocks_stream_to_vector</key>
<param><key>id</key><value>blocks_stream_to_vector_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>num_items</key><value>N</value></param>
</block>
<block>
<key>fft_vxx</key>
<param><key>id</key><value>fft_vxx_0</value></param>
<param><key>fft_size</key><value>N</value></param>
<param><key>forward</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>shift</key><value>True</value></param>
<param><key>window</key><value></value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0</value></param>
<param><key>import</key><value>import numpy</value></param>
</block>
<block>
<key>qtgui_tab_widget</key>
<param><key>id</key><value>mainwidget3</value></param>
<param><key>label0</key><value>PSD (Watts/Hz)</value></param>
<param><key>label1</key><value>Espectro Dinamico en Volts/Hz</value></param>
<param><key>num_tabs</key><value>2</value></param>
</block>
<block>
<key>pad_source</key>
<param><key>id</key><value>pad_source_2</value></param>
<param><key>label</key><value>Tx</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>qtgui_vector_sink_f</key>
<param><key>id</key><value>qtgui_vector_sink_f_0</value></param>
<param><key>gui_hint</key><value>mainwidget3@0:0,0,1,1</value></param>
<param><key>width1</key><value>3</value></param>
<param><key>name</key><value>Titulo</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>vlen</key><value>N</value></param>
<param><key>x_axis_label</key><value>"Frecuencia"</value></param>
<param><key>x_start</key><value>-samp_rate_audio/2+Fc</value></param>
<param><key>x_step</key><value>(samp_rate_audio-1)/N</value></param>
<param><key>x_units</key><value>"Hz"</value></param>
<param><key>ymax</key><value>6e-6</value></param>
<param><key>ymin</key><value>0</value></param>
<param><key>y_axis_label</key><value>"Amplitud (Watt/Hz)"</value></param>
<param><key>y_units</key><value>"Watt/Hz"</value></param>
</block>
<block>
<key>qtgui_vector_sink_f</key>
<param><key>id</key><value>qtgui_vector_sink_f_0_0</value></param>
<param><key>gui_hint</key><value>mainwidget3@1:0,0,1,1</value></param>
<param><key>width1</key><value>3</value></param>
<param><key>name</key><value>Titulo</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>vlen</key><value>N</value></param>
<param><key>x_axis_label</key><value>"Frecuency"</value></param>
<param><key>x_start</key><value>-samp_rate_audio/2+Fc</value></param>
<param><key>x_step</key><value>(samp_rate_audio-1)/N</value></param>
<param><key>x_units</key><value>"Hz"</value></param>
<param><key>ymax</key><value>0.14</value></param>
<param><key>ymin</key><value>0</value></param>
<param><key>y_axis_label</key><value>"Amplitud (V/Hz)"</value></param>
<param><key>y_units</key><value>"V"</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>samp_rate_audio</value></param>
<param><key>label</key><value>Fmuestreo</value></param>
<param><key>value</key><value>22000</value></param>
</block>
<connection><source_block_id>E3TRadio_vector_average_hob_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_mag_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_mag_squared_0</source_block_id><sink_block_id>E3TRadio_vector_average_hob_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0</source_block_id><sink_block_id>qtgui_vector_sink_f_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0_0</source_block_id><sink_block_id>qtgui_vector_sink_f_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_stream_to_vector_0</source_block_id><sink_block_id>fft_vxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fft_vxx_0</source_block_id><sink_block_id>blocks_complex_to_mag_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fft_vxx_0</source_block_id><sink_block_id>blocks_complex_to_mag_squared_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pad_source_2</source_block_id><sink_block_id>blocks_stream_to_vector_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
