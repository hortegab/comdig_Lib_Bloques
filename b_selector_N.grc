<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.9'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>b_selectorN</value></param>
<param><key>author</key><value>Homero Ortega</value></param>
<param><key>category</key><value>comdiguis</value></param>
<param><key>description</key><value>Es una especie de enrutador que permite que cada entrada salga por una salida que el programador establezca asi: en el parametro o0 se indica que entrada debe salir por el puerto o0 y asi sucesivamente. No pueden haber numero repetidos</value></param>
<param><key>generate_options</key><value>hb</value></param>
<param><key>title</key><value>b_selectorN</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>N</value></param>
<param><key>value</key><value>8</value></param>
</block>
<block>
<key>blks2_selector</key>
<param><key>id</key><value>blks2_selector_0</value></param>
<param><key>input_index</key><value>o0</value></param>
<param><key>num_inputs</key><value>N</value></param>
<param><key>num_outputs</key><value>1</value></param>
<param><key>output_index</key><value>0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>blks2_selector</key>
<param><key>id</key><value>blks2_selector_1</value></param>
<param><key>input_index</key><value>o1</value></param>
<param><key>num_inputs</key><value>N</value></param>
<param><key>num_outputs</key><value>1</value></param>
<param><key>output_index</key><value>0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>blks2_selector</key>
<param><key>id</key><value>blks2_selector_2</value></param>
<param><key>input_index</key><value>o2</value></param>
<param><key>num_inputs</key><value>N</value></param>
<param><key>num_outputs</key><value>1</value></param>
<param><key>output_index</key><value>0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>blks2_selector</key>
<param><key>id</key><value>blks2_selector_3</value></param>
<param><key>input_index</key><value>o3</value></param>
<param><key>num_inputs</key><value>N</value></param>
<param><key>num_outputs</key><value>1</value></param>
<param><key>output_index</key><value>0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>blks2_selector</key>
<param><key>id</key><value>blks2_selector_4</value></param>
<param><key>input_index</key><value>o4</value></param>
<param><key>num_inputs</key><value>N</value></param>
<param><key>num_outputs</key><value>1</value></param>
<param><key>output_index</key><value>0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>blks2_selector</key>
<param><key>id</key><value>blks2_selector_5</value></param>
<param><key>input_index</key><value>o5</value></param>
<param><key>num_inputs</key><value>N</value></param>
<param><key>num_outputs</key><value>1</value></param>
<param><key>output_index</key><value>0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>blks2_selector</key>
<param><key>id</key><value>blks2_selector_6</value></param>
<param><key>input_index</key><value>o6</value></param>
<param><key>num_inputs</key><value>N</value></param>
<param><key>num_outputs</key><value>1</value></param>
<param><key>output_index</key><value>0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>blks2_selector</key>
<param><key>id</key><value>blks2_selector_7</value></param>
<param><key>input_index</key><value>o7</value></param>
<param><key>num_inputs</key><value>N</value></param>
<param><key>num_outputs</key><value>1</value></param>
<param><key>output_index</key><value>0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>o0</value></param>
<param><key>label</key><value>o0</value></param>
<param><key>value</key><value>0</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>o1</value></param>
<param><key>label</key><value>o1</value></param>
<param><key>value</key><value>1</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>o2</value></param>
<param><key>label</key><value>o2</value></param>
<param><key>value</key><value>2</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>o3</value></param>
<param><key>label</key><value>o3</value></param>
<param><key>value</key><value>3</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>o4</value></param>
<param><key>label</key><value>o4</value></param>
<param><key>value</key><value>4</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>o5</value></param>
<param><key>label</key><value>o5</value></param>
<param><key>value</key><value>5</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>o6</value></param>
<param><key>label</key><value>o6</value></param>
<param><key>value</key><value>6</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>o7</value></param>
<param><key>label</key><value>o7</value></param>
<param><key>value</key><value>7</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>pad_sink_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>label</key><value>out</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>pad_sink_1</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>label</key><value>out</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>pad_sink_2</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>label</key><value>out</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>pad_sink_3</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>label</key><value>out</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>pad_sink_4</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>label</key><value>out</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>pad_sink_5</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>label</key><value>out</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>pad_sink_6</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>label</key><value>out</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>pad_sink_7</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>label</key><value>out</value></param>
</block>
<block>
<key>pad_source</key>
<param><key>id</key><value>pad_source_0</value></param>
<param><key>label</key><value>in</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>pad_source</key>
<param><key>id</key><value>pad_source_1</value></param>
<param><key>label</key><value>in</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>pad_source</key>
<param><key>id</key><value>pad_source_2</value></param>
<param><key>label</key><value>in</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>pad_source</key>
<param><key>id</key><value>pad_source_3</value></param>
<param><key>label</key><value>in</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>pad_source</key>
<param><key>id</key><value>pad_source_4</value></param>
<param><key>label</key><value>in</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>pad_source</key>
<param><key>id</key><value>pad_source_5</value></param>
<param><key>label</key><value>in</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>pad_source</key>
<param><key>id</key><value>pad_source_6</value></param>
<param><key>label</key><value>in</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>pad_source</key>
<param><key>id</key><value>pad_source_7</value></param>
<param><key>label</key><value>in</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<connection><source_block_id>blks2_selector_0</source_block_id><sink_block_id>pad_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blks2_selector_1</source_block_id><sink_block_id>pad_sink_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blks2_selector_2</source_block_id><sink_block_id>pad_sink_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blks2_selector_3</source_block_id><sink_block_id>pad_sink_3</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blks2_selector_4</source_block_id><sink_block_id>pad_sink_4</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blks2_selector_5</source_block_id><sink_block_id>pad_sink_5</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blks2_selector_6</source_block_id><sink_block_id>pad_sink_6</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blks2_selector_7</source_block_id><sink_block_id>pad_sink_7</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pad_source_0</source_block_id><sink_block_id>blks2_selector_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pad_source_0</source_block_id><sink_block_id>blks2_selector_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pad_source_0</source_block_id><sink_block_id>blks2_selector_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pad_source_0</source_block_id><sink_block_id>blks2_selector_2</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>pad_source_0</source_block_id><sink_block_id>blks2_selector_3</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pad_source_0</source_block_id><sink_block_id>blks2_selector_4</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pad_source_0</source_block_id><sink_block_id>blks2_selector_5</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pad_source_0</source_block_id><sink_block_id>blks2_selector_6</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pad_source_0</source_block_id><sink_block_id>blks2_selector_7</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pad_source_1</source_block_id><sink_block_id>blks2_selector_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>pad_source_1</source_block_id><sink_block_id>blks2_selector_1</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>pad_source_1</source_block_id><sink_block_id>blks2_selector_3</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>pad_source_1</source_block_id><sink_block_id>blks2_selector_4</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>pad_source_1</source_block_id><sink_block_id>blks2_selector_5</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>pad_source_1</source_block_id><sink_block_id>blks2_selector_6</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>pad_source_1</source_block_id><sink_block_id>blks2_selector_7</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>pad_source_2</source_block_id><sink_block_id>blks2_selector_0</sink_block_id><source_key>0</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>pad_source_2</source_block_id><sink_block_id>blks2_selector_1</sink_block_id><source_key>0</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>pad_source_2</source_block_id><sink_block_id>blks2_selector_2</sink_block_id><source_key>0</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>pad_source_2</source_block_id><sink_block_id>blks2_selector_3</sink_block_id><source_key>0</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>pad_source_2</source_block_id><sink_block_id>blks2_selector_4</sink_block_id><source_key>0</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>pad_source_2</source_block_id><sink_block_id>blks2_selector_5</sink_block_id><source_key>0</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>pad_source_2</source_block_id><sink_block_id>blks2_selector_6</sink_block_id><source_key>0</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>pad_source_2</source_block_id><sink_block_id>blks2_selector_7</sink_block_id><source_key>0</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>pad_source_3</source_block_id><sink_block_id>blks2_selector_0</sink_block_id><source_key>0</source_key><sink_key>3</sink_key></connection>
<connection><source_block_id>pad_source_3</source_block_id><sink_block_id>blks2_selector_1</sink_block_id><source_key>0</source_key><sink_key>3</sink_key></connection>
<connection><source_block_id>pad_source_3</source_block_id><sink_block_id>blks2_selector_2</sink_block_id><source_key>0</source_key><sink_key>3</sink_key></connection>
<connection><source_block_id>pad_source_3</source_block_id><sink_block_id>blks2_selector_3</sink_block_id><source_key>0</source_key><sink_key>3</sink_key></connection>
<connection><source_block_id>pad_source_3</source_block_id><sink_block_id>blks2_selector_4</sink_block_id><source_key>0</source_key><sink_key>3</sink_key></connection>
<connection><source_block_id>pad_source_3</source_block_id><sink_block_id>blks2_selector_5</sink_block_id><source_key>0</source_key><sink_key>3</sink_key></connection>
<connection><source_block_id>pad_source_3</source_block_id><sink_block_id>blks2_selector_6</sink_block_id><source_key>0</source_key><sink_key>3</sink_key></connection>
<connection><source_block_id>pad_source_3</source_block_id><sink_block_id>blks2_selector_7</sink_block_id><source_key>0</source_key><sink_key>3</sink_key></connection>
<connection><source_block_id>pad_source_4</source_block_id><sink_block_id>blks2_selector_0</sink_block_id><source_key>0</source_key><sink_key>4</sink_key></connection>
<connection><source_block_id>pad_source_4</source_block_id><sink_block_id>blks2_selector_1</sink_block_id><source_key>0</source_key><sink_key>4</sink_key></connection>
<connection><source_block_id>pad_source_4</source_block_id><sink_block_id>blks2_selector_2</sink_block_id><source_key>0</source_key><sink_key>4</sink_key></connection>
<connection><source_block_id>pad_source_4</source_block_id><sink_block_id>blks2_selector_3</sink_block_id><source_key>0</source_key><sink_key>4</sink_key></connection>
<connection><source_block_id>pad_source_4</source_block_id><sink_block_id>blks2_selector_4</sink_block_id><source_key>0</source_key><sink_key>4</sink_key></connection>
<connection><source_block_id>pad_source_4</source_block_id><sink_block_id>blks2_selector_5</sink_block_id><source_key>0</source_key><sink_key>4</sink_key></connection>
<connection><source_block_id>pad_source_4</source_block_id><sink_block_id>blks2_selector_6</sink_block_id><source_key>0</source_key><sink_key>4</sink_key></connection>
<connection><source_block_id>pad_source_4</source_block_id><sink_block_id>blks2_selector_7</sink_block_id><source_key>0</source_key><sink_key>4</sink_key></connection>
<connection><source_block_id>pad_source_5</source_block_id><sink_block_id>blks2_selector_0</sink_block_id><source_key>0</source_key><sink_key>5</sink_key></connection>
<connection><source_block_id>pad_source_5</source_block_id><sink_block_id>blks2_selector_1</sink_block_id><source_key>0</source_key><sink_key>5</sink_key></connection>
<connection><source_block_id>pad_source_5</source_block_id><sink_block_id>blks2_selector_2</sink_block_id><source_key>0</source_key><sink_key>5</sink_key></connection>
<connection><source_block_id>pad_source_5</source_block_id><sink_block_id>blks2_selector_3</sink_block_id><source_key>0</source_key><sink_key>5</sink_key></connection>
<connection><source_block_id>pad_source_5</source_block_id><sink_block_id>blks2_selector_4</sink_block_id><source_key>0</source_key><sink_key>5</sink_key></connection>
<connection><source_block_id>pad_source_5</source_block_id><sink_block_id>blks2_selector_5</sink_block_id><source_key>0</source_key><sink_key>5</sink_key></connection>
<connection><source_block_id>pad_source_5</source_block_id><sink_block_id>blks2_selector_6</sink_block_id><source_key>0</source_key><sink_key>5</sink_key></connection>
<connection><source_block_id>pad_source_5</source_block_id><sink_block_id>blks2_selector_7</sink_block_id><source_key>0</source_key><sink_key>5</sink_key></connection>
<connection><source_block_id>pad_source_6</source_block_id><sink_block_id>blks2_selector_0</sink_block_id><source_key>0</source_key><sink_key>6</sink_key></connection>
<connection><source_block_id>pad_source_6</source_block_id><sink_block_id>blks2_selector_1</sink_block_id><source_key>0</source_key><sink_key>6</sink_key></connection>
<connection><source_block_id>pad_source_6</source_block_id><sink_block_id>blks2_selector_2</sink_block_id><source_key>0</source_key><sink_key>6</sink_key></connection>
<connection><source_block_id>pad_source_6</source_block_id><sink_block_id>blks2_selector_3</sink_block_id><source_key>0</source_key><sink_key>6</sink_key></connection>
<connection><source_block_id>pad_source_6</source_block_id><sink_block_id>blks2_selector_4</sink_block_id><source_key>0</source_key><sink_key>6</sink_key></connection>
<connection><source_block_id>pad_source_6</source_block_id><sink_block_id>blks2_selector_5</sink_block_id><source_key>0</source_key><sink_key>6</sink_key></connection>
<connection><source_block_id>pad_source_6</source_block_id><sink_block_id>blks2_selector_6</sink_block_id><source_key>0</source_key><sink_key>6</sink_key></connection>
<connection><source_block_id>pad_source_6</source_block_id><sink_block_id>blks2_selector_7</sink_block_id><source_key>0</source_key><sink_key>6</sink_key></connection>
<connection><source_block_id>pad_source_7</source_block_id><sink_block_id>blks2_selector_0</sink_block_id><source_key>0</source_key><sink_key>7</sink_key></connection>
<connection><source_block_id>pad_source_7</source_block_id><sink_block_id>blks2_selector_1</sink_block_id><source_key>0</source_key><sink_key>7</sink_key></connection>
<connection><source_block_id>pad_source_7</source_block_id><sink_block_id>blks2_selector_2</sink_block_id><source_key>0</source_key><sink_key>7</sink_key></connection>
<connection><source_block_id>pad_source_7</source_block_id><sink_block_id>blks2_selector_3</sink_block_id><source_key>0</source_key><sink_key>7</sink_key></connection>
<connection><source_block_id>pad_source_7</source_block_id><sink_block_id>blks2_selector_4</sink_block_id><source_key>0</source_key><sink_key>7</sink_key></connection>
<connection><source_block_id>pad_source_7</source_block_id><sink_block_id>blks2_selector_5</sink_block_id><source_key>0</source_key><sink_key>7</sink_key></connection>
<connection><source_block_id>pad_source_7</source_block_id><sink_block_id>blks2_selector_6</sink_block_id><source_key>0</source_key><sink_key>7</sink_key></connection>
<connection><source_block_id>pad_source_7</source_block_id><sink_block_id>blks2_selector_7</sink_block_id><source_key>0</source_key><sink_key>7</sink_key></connection>
</flow_graph>
