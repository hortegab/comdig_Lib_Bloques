<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.9'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>b_USRP_Sourc_simul_f</value></param>
<param><key>category</key><value>comdiguis</value></param>
<param><key>generate_options</key><value>hb</value></param>
<param><key>title</key><value>b_USRP_Sourc_simul_f</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>Bandwidth</value></param>
<param><key>label</key><value>Bandwidth (Hz)</value></param>
<param><key>value</key><value>0</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>Center_Freq</value></param>
<param><key>label</key><value>Center_Freq</value></param>
<param><key>value</key><value>50000000</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>Gain_Value_dB</value></param>
<param><key>label</key><value>Gain_Value (dB)</value></param>
<param><key>value</key><value>0</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>Lo_que_falta</value></param>
<param><key>note</key><value>poner amplificador, poner rango dinamico; condicion para B=0</value></param>
</block>
<block>
<key>b_downconverter_fc</key>
<param><key>id</key><value>b_downconverter_fc_0</value></param>
<param><key>BW</key><value>samp_rate/2</value></param>
<param><key>Fc</key><value>Center_Freq</value></param>
<param><key>samp_rate</key><value>samp_rate_rf</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>pad_sink_0_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>label</key><value>out</value></param>
</block>
<block>
<key>pad_source</key>
<param><key>id</key><value>pad_source_0_0</value></param>
<param><key>label</key><value>in</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>rational_resampler_xxx</key>
<param><key>id</key><value>rational_resampler_xxx_0_0</value></param>
<param><key>decim</key><value>samp_rate_rf</value></param>
<param><key>interp</key><value>samp_rate</value></param>
<param><key>taps</key><value></value></param>
<param><key>type</key><value>ccc</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>label</key><value>samp_rate</value></param>
<param><key>value</key><value>200000</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>samp_rate_rf</value></param>
<param><key>label</key><value>samp_rate_rf</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>50000000+200000</value></param>
</block>
<connection><source_block_id>b_downconverter_fc_0</source_block_id><sink_block_id>rational_resampler_xxx_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pad_source_0_0</source_block_id><sink_block_id>b_downconverter_fc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rational_resampler_xxx_0_0</source_block_id><sink_block_id>pad_sink_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
