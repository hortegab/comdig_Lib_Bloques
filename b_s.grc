<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.8'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>s</value></param>
<param><key>author</key><value>Homero Ortega Boada. Universidad Industrial de Santander</value></param>
<param><key>category</key><value>borrar</value></param>
<param><key>description</key><value>Etiqueta de salida. Para no tener que hacer tantas interconexiones</value></param>
<param><key>generate_options</key><value>hb</value></param>
<param><key>title</key><value>s</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>I</value></param>
<param><key>label</key><value>Id</value></param>
<param><key>value</key><value>0</value></param>
</block>
<block>
<key>pad_source</key>
<param><key>id</key><value>pad_source_0</value></param>
<param><key>label</key><value>in</value></param>
<param><key>type</key><value></value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>s1</value></param>
<param><key>stream_id</key><value>I</value></param>
</block>
<connection><source_block_id>pad_source_0</source_block_id><sink_block_id>s1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
