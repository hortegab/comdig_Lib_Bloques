<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.9'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>b_PCM_Encoder_Bb</value></param>
<param><key>author</key><value>Homero Ortega Boada, Universidad Industrial de Santander</value></param>
<param><key>category</key><value>comdiguis</value></param>
<param><key>description</key><value>Recibe una senal tipo Byte y la convierte a bits pero no sin antes organizarlos por tramas o paquetes (frames) imaginados por el usuario con el fin de poder lograr que el bloque Packet Decoder pueda realizar la alineacion de trama (Frame alignment). Ojo la entrada del bloque son amplitudes tipo Byte, pero la salida son bits puros, desempaquetados segun el sistema, pero empaquetados segun la imaginacion del usuario.  Como todo paquete, tiene un encabezado y una carga util. Parametros usados: payload (Bytes) -  es el numero de bytes que usted desea de carga util para cada trama; AccessCode - (string de 1s y 0s, la cantidad total de ellos debe ser multiplo de 8) es el codigo o palabra clave que permite al bloque en recepcion reconocer las tramas. Nota: es claro que el bloque produce un numero mayor de bytes que los que recibe, de modo que es importante saber calcular la rata de bits, o la rata de Bytes o la frecuencia de muestreo que se produce. Lo importante es saber que la rata se bits se eleva en un monto igual a SpB=[1+(10+numero de bytes contenidos en el AccesCode)/(payload)]. De modo que la rata de bits, asi como la rata de Bytes y la frecuencia de muestreo se eleva  SpB veces a la salida con respecto a la entrada. No se hizo un bloque que haga pareja con este bloque pues ese papel lo puede jugar el bloque Packet Decoder.  SpB se puede calcular con este comando de Python: 1.+(len(list(code))/8.+10.)/payload</value></param>
<param><key>generate_options</key><value>hb</value></param>
<param><key>title</key><value>b_PCM_Encoder_Bb</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>BytesRedundancy</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>value</key><value>LengthCode/8.+10.</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>LengthCode</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>value</key><value>len(list(code))</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>SpB</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>value</key><value>(len(list(code))/8.+10.)/payload+1.</value></param>
</block>
<block>
<key>blks2_packet_encoder</key>
<param><key>id</key><value>blks2_packet_encoder_0_0_0</value></param>
<param><key>access_code</key><value>code</value></param>
<param><key>bits_per_symbol</key><value>8</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>pad_for_usrp</key><value>False</value></param>
<param><key>payload_length</key><value>payload</value></param>
<param><key>preamble</key><value></value></param>
<param><key>samples_per_symbol</key><value>1</value></param>
</block>
<block>
<key>blocks_packed_to_unpacked_xx</key>
<param><key>id</key><value>blocks_packed_to_unpacked_xx_0</value></param>
<param><key>bits_per_chunk</key><value>1</value></param>
<param><key>endianness</key><value>gr.GR_MSB_FIRST</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>blocks_unpack_k_bits_bb</key>
<param><key>id</key><value>blocks_unpack_k_bits_bb_0_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>k</key><value>8</value></param>
</block>
<block>
<key>blocks_vector_source_x</key>
<param><key>id</key><value>blocks_vector_source_x_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>repeat</key><value>True</value></param>
<param><key>vector</key><value>(SpB,SpB)</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>code</value></param>
<param><key>label</key><value>AccessCode</value></param>
<param><key>value</key><value>'0101100110111011000101010111111010010011100010110100011010100011'</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>f1</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>label</key><value>SpB (No tocar esto)</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>Sp</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>pad_sink_0</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>label</key><value>out</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>pad_sink_0_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>label</key><value>SpB</value></param>
<param><key>optional</key><value>True</value></param>
</block>
<block>
<key>pad_source</key>
<param><key>id</key><value>pad_source_0</value></param>
<param><key>label</key><value>in</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>payload</value></param>
<param><key>label</key><value>payload</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>18</value></param>
</block>
<connection><source_block_id>blks2_packet_encoder_0_0_0</source_block_id><sink_block_id>blocks_packed_to_unpacked_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blks2_packet_encoder_0_0_0</source_block_id><sink_block_id>blocks_unpack_k_bits_bb_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_packed_to_unpacked_xx_0</source_block_id><sink_block_id>pad_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_unpack_k_bits_bb_0_0</source_block_id><sink_block_id>pad_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_vector_source_x_0</source_block_id><sink_block_id>pad_sink_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pad_source_0</source_block_id><sink_block_id>blks2_packet_encoder_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
