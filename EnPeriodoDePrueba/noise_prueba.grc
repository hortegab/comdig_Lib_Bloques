<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.9'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>ber_simulation</value></param>
<param><key>author</key><value>Example</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>description</key><value>Adjust the noise and constellation... see what happens!</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
<param><key>run</key><value>run_stop</value></param>
<param><key>title</key><value>BER Simulation</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>Anoise_max</value></param>
<param><key>value</key><value>1.0 / math.sqrt(2.0 * Bps* 10**(EbNo_dB_min/10.))</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>Anoise_min</value></param>
<param><key>value</key><value>1.0 / math.sqrt(2.0 * Bps* 10**(EbNo_dB_max/10.))</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>Bps</value></param>
<param><key>value</key><value>int(math.log(M,2))</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>EbN0</value></param>
<param><key>value</key><value>1</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>label</key><value>Eb / N0 (dB)</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>-10</value></param>
<param><key>step</key><value>1</value></param>
<param><key>stop</key><value>200</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>EbNo_dB_max</value></param>
<param><key>value</key><value>10.</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>EbNo_dB_min</value></param>
<param><key>value</key><value>-4</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>M</value></param>
<param><key>value</key><value>len(Constelacion)</value></param>
</block>
<block>
<key>variable_constellation</key>
<param><key>id</key><value>MiconstellationObject</value></param>
<param><key>const_points</key><value>Constelacion</value></param>
<param><key>dims</key><value>1</value></param>
<param><key>rot_sym</key><value>4</value></param>
<param><key>precision</key><value>8</value></param>
<param><key>sym_map</key><value></value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>N</value></param>
<param><key>value</key><value>9000000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>Noise_puntos</value></param>
<param><key>value</key><value>20</value></param>
</block>
<block>
<key>variable_qtgui_check_box</key>
<param><key>id</key><value>run_stop</value></param>
<param><key>value</key><value>True</value></param>
<param><key>false</key><value>False</value></param>
<param><key>gui_hint</key><value>0,0,1,1</value></param>
<param><key>label</key><value>Inicial/Parar</value></param>
<param><key>true</key><value>True</value></param>
<param><key>type</key><value>int</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>N</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>Constelacion</value></param>
<param><key>label</key><value>Constelacion</value></param>
<param><key>value</key><value>[1.+0.j,   0.+1.j,   -1.+0.j,  0.-1.j ]</value></param>
</block>
<block>
<key>E3TRadio_Zero_Order_Hold</key>
<param><key>id</key><value>E3TRadio_Zero_Order_Hold_0</value></param>
<param><key>k</key><value>N</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>blocks_throttle_0</value></param>
<param><key>samples_per_second</key><value>samp_rate</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_vector_source_x</key>
<param><key>id</key><value>blocks_vector_source_x_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>repeat</key><value>False</value></param>
<param><key>vector</key><value>numpy.linspace(Anoise_min,Anoise_max,Noise_puntos)</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import</value></param>
<param><key>import</key><value>import math</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0</value></param>
<param><key>import</key><value>import numpy</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value></value></param>
<param><key>size</key><value>Noise_puntos*2*N</value></param>
<param><key>srate</key><value>samp_rate</value></param>
<param><key>type</key><value>float</value></param>
<param><key>ymax</key><value>Anoise_max</value></param>
<param><key>ymin</key><value>Anoise_min</value></param>
</block>
<connection><source_block_id>E3TRadio_Zero_Order_Hold_0</source_block_id><sink_block_id>qtgui_time_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>E3TRadio_Zero_Order_Hold_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_vector_source_x_0</source_block_id><sink_block_id>blocks_throttle_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
