<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.13'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>b_Canal_AWGN</value></param>
<param><key>author</key><value>Homero Ortega Boada. Universidad Industrial de Santander</value></param>
<param><key>category</key><value>comdiguis</value></param>
<param><key>description</key><value>Este bloque es un simulador de un canal AWGN (Additive White Gaussian Noise) en bandabase. De modo que solo tiene tres características: suma ruido blanco a la señal,  restringe el ancho de banda e Introduce un retardo a la señal. Parametros: Ch_NodB - altura de la PSD del ruido blanco bandabase; samp_rate - frecuencia de muestreo de la señal; BW - ancho de banda sobre el cual desea ver el efecto del ruido, por lo general es el mismo valor de la frecuencia de muestreo sobre 2, Ch_Toffset - retardo dado en muestraas que el canal introduce</value></param>
<param><key>generate_options</key><value>hb</value></param>
<param><key>title</key><value>b_Canal_AWGN_cc</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>BW</value></param>
<param><key>label</key><value>BW (Hz)</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>1000</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>Ch_NodB</value></param>
<param><key>label</key><value>Ch. W.Noise (No in dB)</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>-20</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>Ch_Toffset</value></param>
<param><key>label</key><value>Channel Toffset</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>0</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>Note</value></param>
<param><key>note</key><value>Esta ramificacion de abajo es la que introduce las fluctuaciones en magnitud</value></param>
</block>
<block>
<key>b_noise_dB_cc</key>
<param><key>id</key><value>b_noise_dB_cc_0</value></param>
<param><key>NodB</key><value>Ch_NodB</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
</block>
<block>
<key>blocks_add_xx</key>
<param><key>id</key><value>blocks_add_xx_0</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_delay</key>
<param><key>id</key><value>blocks_delay_0</value></param>
<param><key>delay</key><value>Ch_Toffset</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0_1</value></param>
<param><key>import</key><value>import cmath</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0_1_0</value></param>
<param><key>import</key><value>import numpy</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0_1_0_0</value></param>
<param><key>import</key><value>import random</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0_1_1</value></param>
<param><key>import</key><value>import math</value></param>
</block>
<block>
<key>low_pass_filter</key>
<param><key>id</key><value>low_pass_filter_0</value></param>
<param><key>cutoff_freq</key><value>BW</value></param>
<param><key>decim</key><value>1</value></param>
<param><key>type</key><value>fir_filter_ccf</value></param>
<param><key>gain</key><value>1</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>width</key><value>BW/16</value></param>
<param><key>win</key><value>firdes.WIN_HAMMING</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>pad_sink_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>label</key><value>out</value></param>
</block>
<block>
<key>pad_source</key>
<param><key>id</key><value>pad_source_0</value></param>
<param><key>label</key><value>in</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>label</key><value>samp_rate</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>1000</value></param>
</block>
<connection><source_block_id>b_noise_dB_cc_0</source_block_id><sink_block_id>blocks_add_xx_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_add_xx_0</source_block_id><sink_block_id>low_pass_filter_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_delay_0</source_block_id><sink_block_id>blocks_add_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>low_pass_filter_0</source_block_id><sink_block_id>pad_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pad_source_0</source_block_id><sink_block_id>blocks_delay_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
