<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.8'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>b_ClockRecSamp_m</value></param>
<param><key>author</key><value>Done by: Homero Ortega Boada. Universidad Industrial de Santander</value></param>
<param><key>category</key><value>comdiguis</value></param>
<param><key>description</key><value>Es un Clock o Timming Recovery con muestreo pero manual. Recibe una senal con modulacion digital basada en constelaciones, que llega sobremuestreada a la razon de Sps muestras por simbolo, proveniente de un canal, usted selecciona manualmente el mejor instante de muestreo con la ayuda de un diagrama de ojo que este bloque le brinda, selecciona el instante en que el ojo aparece mas abierto, finalmente el bloque produce la senal muestreada en el instante seleccionado por usted. En este sentido, este bloque es un decimador, pues por cada Sps muestras produce solo una. Entrega entonces una senal con una frecuencia de muestreo igual a la rata de simbolos. Parametros usados: samp_rate (Hz) - es la rata de muestreo de la senal recibida; Sps (muestras) - es el numero de muestras por simbolo que trae la senal entrante</value></param>
<param><key>generate_options</key><value>hb_qt_gui</value></param>
<param><key>title</key><value>b_ClockRecSamp_m</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>AlphaLineas</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>value</key><value>0.5</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>Delay</value></param>
<param><key>value</key><value>int(Sps/2)</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>gui_hint</key><value>1,0</value></param>
<param><key>label</key><value>Mueva aqui para Centrar el Ojo</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>1</value></param>
<param><key>stop</key><value>Sps</value></param>
<param><key>rangeType</key><value>int</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>Delay</value></param>
<param><key>value</key><value>Sps-TimingDelay</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>GrosorLineas</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>value</key><value>20</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>N_eyes</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>value</key><value>2</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>TimingDelay</value></param>
<param><key>value</key><value>0</value></param>
<param><key>gui_hint</key><value>1,0</value></param>
<param><key>label</key><value>Seleccione instante en que ojo esta mas abierto</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>1</value></param>
<param><key>stop</key><value>Sps-1</value></param>
<param><key>rangeType</key><value>int</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>Ymax</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>value</key><value>2.</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>Ymin</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>value</key><value>-2.</value></param>
</block>
<block>
<key>E3TRadio_zero_order_hold2_cc</key>
<param><key>id</key><value>E3TRadio_zero_order_hold2_cc_0</value></param>
<param><key>k</key><value>Sps</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>Sps</value></param>
<param><key>label</key><value>Samples per symbol</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>64</value></param>
</block>
<block>
<key>b_Eye_Diagram_c</key>
<param><key>id</key><value>b_Eye_Diagram_c_0</value></param>
<param><key>AlphaLineas</key><value>0.5</value></param>
<param><key>gui_hint</key><value>0,0,1,2</value></param>
<param><key>GrosorLineas</key><value>20</value></param>
<param><key>N_eyes</key><value>2</value></param>
<param><key>Samprate</key><value>samp_rate</value></param>
<param><key>Sps</key><value>Sps</value></param>
<param><key>Ymax</key><value>1.5</value></param>
<param><key>Ymin</key><value>-1.5</value></param>
</block>
<block>
<key>b_sampler_cc</key>
<param><key>id</key><value>b_sampler_cc_0</value></param>
<param><key>DelayDiez</key><value>TimingDelay</value></param>
<param><key>Sps</key><value>Sps</value></param>
</block>
<block>
<key>blocks_complex_to_float</key>
<param><key>id</key><value>blocks_complex_to_float_0</value></param>
<param><key>_enabled</key><value>0</value></param>
</block>
<block>
<key>blocks_complex_to_float</key>
<param><key>id</key><value>blocks_complex_to_float_0_0</value></param>
<param><key>_enabled</key><value>0</value></param>
</block>
<block>
<key>blocks_delay</key>
<param><key>id</key><value>blocks_delay_0</value></param>
<param><key>delay</key><value>Sps*2+Delay</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_delay</key>
<param><key>id</key><value>blocks_delay_0_0</value></param>
<param><key>delay</key><value>Sps*3+Delay</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_delay</key>
<param><key>id</key><value>blocks_delay_0_0_0</value></param>
<param><key>delay</key><value>Sps*3+Delay</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_delay</key>
<param><key>id</key><value>blocks_delay_0_1</value></param>
<param><key>delay</key><value>Sps*4+Delay</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_delay</key>
<param><key>id</key><value>blocks_delay_0_1_0</value></param>
<param><key>delay</key><value>Sps*4+Delay</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_delay</key>
<param><key>id</key><value>blocks_delay_0_2</value></param>
<param><key>delay</key><value>Sps*5+Delay</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_delay</key>
<param><key>id</key><value>blocks_delay_0_2_0</value></param>
<param><key>delay</key><value>Sps*5+Delay</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_delay</key>
<param><key>id</key><value>blocks_delay_0_3</value></param>
<param><key>delay</key><value>Sps*6+Delay</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_delay</key>
<param><key>id</key><value>blocks_delay_0_3_0</value></param>
<param><key>delay</key><value>Sps*9+Delay</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_delay</key>
<param><key>id</key><value>blocks_delay_0_3_0_0</value></param>
<param><key>delay</key><value>Delay</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_delay</key>
<param><key>id</key><value>blocks_delay_0_3_0_0_0</value></param>
<param><key>delay</key><value>Delay</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_delay</key>
<param><key>id</key><value>blocks_delay_0_3_0_1</value></param>
<param><key>delay</key><value>Sps*9+Delay</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_delay</key>
<param><key>id</key><value>blocks_delay_0_3_1</value></param>
<param><key>delay</key><value>Sps*6+Delay</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_delay</key>
<param><key>id</key><value>blocks_delay_0_4</value></param>
<param><key>delay</key><value>Sps*7+Delay</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_delay</key>
<param><key>id</key><value>blocks_delay_0_4_0</value></param>
<param><key>delay</key><value>Sps*7+Delay</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_delay</key>
<param><key>id</key><value>blocks_delay_0_5</value></param>
<param><key>delay</key><value>Sps*8+Delay</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_delay</key>
<param><key>id</key><value>blocks_delay_0_5_0</value></param>
<param><key>delay</key><value>Sps*8+Delay</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_delay</key>
<param><key>id</key><value>blocks_delay_0_6</value></param>
<param><key>delay</key><value>Sps*1+Delay</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_delay</key>
<param><key>id</key><value>blocks_delay_0_6_0</value></param>
<param><key>delay</key><value>Sps*1+Delay</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_delay</key>
<param><key>id</key><value>blocks_delay_0_7</value></param>
<param><key>delay</key><value>Sps*2+Delay</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>pad_sink_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>label</key><value>out</value></param>
</block>
<block>
<key>pad_source</key>
<param><key>id</key><value>pad_source_0</value></param>
<param><key>label</key><value>in</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>qtgui_const_sink_x</key>
<param><key>id</key><value>qtgui_const_sink_x_0_0</value></param>
<param><key>gui_hint</key><value>1,1,1,1</value></param>
<param><key>alpha1</key><value>0.5</value></param>
<param><key>color1</key><value>"black"</value></param>
<param><key>label1</key><value>Recibida</value></param>
<param><key>label2</key><value>Muestreada</value></param>
<param><key>width2</key><value>2</value></param>
<param><key>name</key><value></value></param>
<param><key>nconnections</key><value>2</value></param>
<param><key>size</key><value>1024</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>xmax</key><value>2.5</value></param>
<param><key>xmin</key><value>-2.5</value></param>
<param><key>ymax</key><value>1.5</value></param>
<param><key>ymin</key><value>-1.5</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0_0_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>gui_hint</key><value>0,0</value></param>
<param><key>alpha1</key><value>AlphaLineas</value></param>
<param><key>color1</key><value>"black"</value></param>
<param><key>label1</key><value></value></param>
<param><key>width1</key><value>GrosorLineas</value></param>
<param><key>alpha10</key><value>1.</value></param>
<param><key>color10</key><value>"red"</value></param>
<param><key>label10</key><value></value></param>
<param><key>marker10</key><value>0</value></param>
<param><key>alpha2</key><value>AlphaLineas</value></param>
<param><key>color2</key><value>"black"</value></param>
<param><key>label2</key><value></value></param>
<param><key>width2</key><value>GrosorLineas</value></param>
<param><key>alpha3</key><value>AlphaLineas</value></param>
<param><key>color3</key><value>"black"</value></param>
<param><key>label3</key><value></value></param>
<param><key>width3</key><value>GrosorLineas</value></param>
<param><key>alpha4</key><value>AlphaLineas</value></param>
<param><key>color4</key><value>"black"</value></param>
<param><key>label4</key><value></value></param>
<param><key>width4</key><value>GrosorLineas</value></param>
<param><key>alpha5</key><value>AlphaLineas</value></param>
<param><key>color5</key><value>"black"</value></param>
<param><key>label5</key><value></value></param>
<param><key>width5</key><value>GrosorLineas</value></param>
<param><key>alpha6</key><value>AlphaLineas</value></param>
<param><key>color6</key><value>"black"</value></param>
<param><key>label6</key><value></value></param>
<param><key>width6</key><value>GrosorLineas</value></param>
<param><key>alpha7</key><value>AlphaLineas</value></param>
<param><key>color7</key><value>"black"</value></param>
<param><key>label7</key><value></value></param>
<param><key>width7</key><value>GrosorLineas</value></param>
<param><key>alpha8</key><value>AlphaLineas</value></param>
<param><key>color8</key><value>"black"</value></param>
<param><key>label8</key><value></value></param>
<param><key>width8</key><value>GrosorLineas</value></param>
<param><key>alpha9</key><value>AlphaLineas</value></param>
<param><key>color9</key><value>"black"</value></param>
<param><key>label9</key><value></value></param>
<param><key>width9</key><value>GrosorLineas</value></param>
<param><key>name</key><value>Parte Real</value></param>
<param><key>nconnections</key><value>10</value></param>
<param><key>size</key><value>int(Sps*N_eyes)</value></param>
<param><key>srate</key><value>samp_rate</value></param>
<param><key>type</key><value>float</value></param>
<param><key>ymax</key><value>Ymax</value></param>
<param><key>ymin</key><value>Ymin</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0_0_0_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>gui_hint</key><value>0,1</value></param>
<param><key>alpha1</key><value>AlphaLineas</value></param>
<param><key>color1</key><value>"black"</value></param>
<param><key>label1</key><value></value></param>
<param><key>width1</key><value>GrosorLineas</value></param>
<param><key>alpha10</key><value>1.</value></param>
<param><key>color10</key><value>"red"</value></param>
<param><key>label10</key><value></value></param>
<param><key>marker10</key><value>0</value></param>
<param><key>alpha2</key><value>AlphaLineas</value></param>
<param><key>color2</key><value>"black"</value></param>
<param><key>label2</key><value></value></param>
<param><key>width2</key><value>GrosorLineas</value></param>
<param><key>alpha3</key><value>AlphaLineas</value></param>
<param><key>color3</key><value>"black"</value></param>
<param><key>label3</key><value></value></param>
<param><key>width3</key><value>GrosorLineas</value></param>
<param><key>alpha4</key><value>AlphaLineas</value></param>
<param><key>color4</key><value>"black"</value></param>
<param><key>label4</key><value></value></param>
<param><key>width4</key><value>GrosorLineas</value></param>
<param><key>alpha5</key><value>AlphaLineas</value></param>
<param><key>color5</key><value>"black"</value></param>
<param><key>label5</key><value></value></param>
<param><key>width5</key><value>GrosorLineas</value></param>
<param><key>alpha6</key><value>AlphaLineas</value></param>
<param><key>color6</key><value>"black"</value></param>
<param><key>label6</key><value></value></param>
<param><key>width6</key><value>GrosorLineas</value></param>
<param><key>alpha7</key><value>AlphaLineas</value></param>
<param><key>color7</key><value>"black"</value></param>
<param><key>label7</key><value></value></param>
<param><key>width7</key><value>GrosorLineas</value></param>
<param><key>alpha8</key><value>AlphaLineas</value></param>
<param><key>color8</key><value>"black"</value></param>
<param><key>label8</key><value></value></param>
<param><key>width8</key><value>GrosorLineas</value></param>
<param><key>alpha9</key><value>AlphaLineas</value></param>
<param><key>color9</key><value>"black"</value></param>
<param><key>label9</key><value></value></param>
<param><key>width9</key><value>GrosorLineas</value></param>
<param><key>name</key><value>Parte Imaginaria</value></param>
<param><key>nconnections</key><value>10</value></param>
<param><key>size</key><value>int(Sps*N_eyes)</value></param>
<param><key>srate</key><value>samp_rate</value></param>
<param><key>type</key><value>float</value></param>
<param><key>ymax</key><value>Ymax</value></param>
<param><key>ymin</key><value>Ymin</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>label</key><value>samp_rate</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>64</value></param>
</block>
<connection><source_block_id>E3TRadio_zero_order_hold2_cc_0</source_block_id><sink_block_id>qtgui_const_sink_x_0_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>b_sampler_cc_0</source_block_id><sink_block_id>b_Eye_Diagram_c_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>b_sampler_cc_0</source_block_id><sink_block_id>blocks_complex_to_float_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>b_sampler_cc_0</source_block_id><sink_block_id>E3TRadio_zero_order_hold2_cc_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>b_sampler_cc_0</source_block_id><sink_block_id>pad_sink_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_float_0</source_block_id><sink_block_id>blocks_delay_0_3_0_0_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_float_0</source_block_id><sink_block_id>blocks_delay_0_3_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_float_0_0</source_block_id><sink_block_id>blocks_delay_0_0_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_float_0_0</source_block_id><sink_block_id>blocks_delay_0_1_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_float_0_0</source_block_id><sink_block_id>blocks_delay_0_2_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_float_0_0</source_block_id><sink_block_id>blocks_delay_0_3_0_1</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_float_0_0</source_block_id><sink_block_id>blocks_delay_0_3_1</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_float_0_0</source_block_id><sink_block_id>blocks_delay_0_4_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_float_0_0</source_block_id><sink_block_id>blocks_delay_0_5_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_float_0_0</source_block_id><sink_block_id>blocks_delay_0_6_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_float_0_0</source_block_id><sink_block_id>blocks_delay_0_7</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_float_0_0</source_block_id><sink_block_id>blocks_delay_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_float_0_0</source_block_id><sink_block_id>blocks_delay_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_float_0_0</source_block_id><sink_block_id>blocks_delay_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_float_0_0</source_block_id><sink_block_id>blocks_delay_0_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_float_0_0</source_block_id><sink_block_id>blocks_delay_0_3</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_float_0_0</source_block_id><sink_block_id>blocks_delay_0_3_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_float_0_0</source_block_id><sink_block_id>blocks_delay_0_4</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_float_0_0</source_block_id><sink_block_id>blocks_delay_0_5</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_float_0_0</source_block_id><sink_block_id>blocks_delay_0_6</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_delay_0</source_block_id><sink_block_id>qtgui_time_sink_x_0_0_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_delay_0_0</source_block_id><sink_block_id>qtgui_time_sink_x_0_0_0</sink_block_id><source_key>0</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>blocks_delay_0_0_0</source_block_id><sink_block_id>qtgui_time_sink_x_0_0_0_0</sink_block_id><source_key>0</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>blocks_delay_0_1</source_block_id><sink_block_id>qtgui_time_sink_x_0_0_0</sink_block_id><source_key>0</source_key><sink_key>3</sink_key></connection>
<connection><source_block_id>blocks_delay_0_1_0</source_block_id><sink_block_id>qtgui_time_sink_x_0_0_0_0</sink_block_id><source_key>0</source_key><sink_key>3</sink_key></connection>
<connection><source_block_id>blocks_delay_0_2</source_block_id><sink_block_id>qtgui_time_sink_x_0_0_0</sink_block_id><source_key>0</source_key><sink_key>4</sink_key></connection>
<connection><source_block_id>blocks_delay_0_2_0</source_block_id><sink_block_id>qtgui_time_sink_x_0_0_0_0</sink_block_id><source_key>0</source_key><sink_key>4</sink_key></connection>
<connection><source_block_id>blocks_delay_0_3</source_block_id><sink_block_id>qtgui_time_sink_x_0_0_0</sink_block_id><source_key>0</source_key><sink_key>5</sink_key></connection>
<connection><source_block_id>blocks_delay_0_3_0</source_block_id><sink_block_id>qtgui_time_sink_x_0_0_0</sink_block_id><source_key>0</source_key><sink_key>8</sink_key></connection>
<connection><source_block_id>blocks_delay_0_3_0_0</source_block_id><sink_block_id>qtgui_time_sink_x_0_0_0</sink_block_id><source_key>0</source_key><sink_key>9</sink_key></connection>
<connection><source_block_id>blocks_delay_0_3_0_0_0</source_block_id><sink_block_id>qtgui_time_sink_x_0_0_0_0</sink_block_id><source_key>0</source_key><sink_key>9</sink_key></connection>
<connection><source_block_id>blocks_delay_0_3_0_1</source_block_id><sink_block_id>qtgui_time_sink_x_0_0_0_0</sink_block_id><source_key>0</source_key><sink_key>8</sink_key></connection>
<connection><source_block_id>blocks_delay_0_3_1</source_block_id><sink_block_id>qtgui_time_sink_x_0_0_0_0</sink_block_id><source_key>0</source_key><sink_key>5</sink_key></connection>
<connection><source_block_id>blocks_delay_0_4</source_block_id><sink_block_id>qtgui_time_sink_x_0_0_0</sink_block_id><source_key>0</source_key><sink_key>6</sink_key></connection>
<connection><source_block_id>blocks_delay_0_4_0</source_block_id><sink_block_id>qtgui_time_sink_x_0_0_0_0</sink_block_id><source_key>0</source_key><sink_key>6</sink_key></connection>
<connection><source_block_id>blocks_delay_0_5</source_block_id><sink_block_id>qtgui_time_sink_x_0_0_0</sink_block_id><source_key>0</source_key><sink_key>7</sink_key></connection>
<connection><source_block_id>blocks_delay_0_5_0</source_block_id><sink_block_id>qtgui_time_sink_x_0_0_0_0</sink_block_id><source_key>0</source_key><sink_key>7</sink_key></connection>
<connection><source_block_id>blocks_delay_0_6</source_block_id><sink_block_id>qtgui_time_sink_x_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_delay_0_6_0</source_block_id><sink_block_id>qtgui_time_sink_x_0_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_delay_0_7</source_block_id><sink_block_id>qtgui_time_sink_x_0_0_0_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>pad_source_0</source_block_id><sink_block_id>b_Eye_Diagram_c_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pad_source_0</source_block_id><sink_block_id>b_sampler_cc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pad_source_0</source_block_id><sink_block_id>blocks_complex_to_float_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pad_source_0</source_block_id><sink_block_id>qtgui_const_sink_x_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
