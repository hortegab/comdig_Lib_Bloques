<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.8'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>b_QT_tunner_sampler</value></param>
<param><key>author</key><value>Homero Ortega Boada. Universidad Industrial de Santander</value></param>
<param><key>category</key><value>borrar</value></param>
<param><key>description</key><value>Permite sintonizar manualmente el canal al punto de entregar la senal correctamente muestreada. Parametros usados: samp_rate (Hz) la frecuencia de muestreo de la senal entrante; sps (muestras) numero de muestras por simbolo en la senal entrante; Delay Tuning (muestras) el retrazo que se introduce a la senal antes de aplicarle el muestreo; PhiTuning (Rad) angulo usado para corregir la desviacion de angulo producida por el canal; F_Tuning (Hz) correccion de la desviacion de frecuencias; Nscope (muestras) numero de bits a mostrar en el scope</value></param>
<param><key>generate_options</key><value>hb_qt_gui</value></param>
<param><key>run</key><value>run_stop</value></param>
<param><key>title</key><value>b_QT_tunner_sampler</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>DelayTuning</value></param>
<param><key>value</key><value>0</value></param>
<param><key>gui_hint</key><value>pestana@3:0,0,1,1</value></param>
<param><key>label</key><value>Retardo antes de muestreo </value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>1</value></param>
<param><key>stop</key><value>sps-1</value></param>
<param><key>rangeType</key><value>int</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>F_Tuning</value></param>
<param><key>value</key><value>0</value></param>
<param><key>gui_hint</key><value>pestana@3:1,0,1,1</value></param>
<param><key>label</key><value>Rx Frequency tunining</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>10./1000.</value></param>
<param><key>stop</key><value>10.</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>Foffset</value></param>
<param><key>value</key><value>0</value></param>
<param><key>gui_hint</key><value>0,2,1,1</value></param>
<param><key>label</key><value>Offset de frec.</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>0.01</value></param>
<param><key>stop</key><value>5</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>Kruido</value></param>
<param><key>value</key><value>0.01</value></param>
<param><key>gui_hint</key><value>0,1,1,1</value></param>
<param><key>label</key><value>Nivel del Ruido</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>0.005</value></param>
<param><key>stop</key><value>1</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>Nscope_span</value></param>
<param><key>value</key><value>24</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>PhiTuning</value></param>
<param><key>value</key><value>0</value></param>
<param><key>gui_hint</key><value>pestana@3:0,1,1,1</value></param>
<param><key>label</key><value>Rx angle tunining</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>(numpy.pi)*2/200</value></param>
<param><key>stop</key><value>(numpy.pi)*2</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>phi</value></param>
<param><key>value</key><value>0.</value></param>
<param><key>gui_hint</key><value>0,3,1,1</value></param>
<param><key>label</key><value>Angulo</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>-numpy.pi</value></param>
<param><key>step</key><value>numpy.pi/100.</value></param>
<param><key>stop</key><value>numpy.pi</value></param>
</block>
<block>
<key>variable_qtgui_check_box</key>
<param><key>id</key><value>run_stop</value></param>
<param><key>value</key><value>True</value></param>
<param><key>false</key><value>False</value></param>
<param><key>gui_hint</key><value>0,0,1,1</value></param>
<param><key>label</key><value>Inicial/Parar</value></param>
<param><key>true</key><value>True</value></param>
<param><key>type</key><value>int</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>2000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>sps</value></param>
<param><key>value</key><value>8</value></param>
</block>
<block>
<key>b_sampler_cc</key>
<param><key>id</key><value>b_sampler_cc_0</value></param>
<param><key>DelayDiez</key><value>0</value></param>
<param><key>Sps</key><value>sps</value></param>
</block>
<block>
<key>b_tunner</key>
<param><key>id</key><value>b_tunner_0</value></param>
<param><key>fdesv</key><value>-F_Tuning</value></param>
<param><key>NDelay</key><value>DelayTuning</value></param>
<param><key>phi</key><value>PhiTuning</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0</value></param>
<param><key>import</key><value>import math</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0_1</value></param>
<param><key>import</key><value>import cmath</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0_1_0</value></param>
<param><key>import</key><value>import numpy</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0_1_1</value></param>
<param><key>import</key><value>import random</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>pad_sink_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>label</key><value>out</value></param>
</block>
<block>
<key>pad_source</key>
<param><key>id</key><value>pad_source_0</value></param>
<param><key>label</key><value>in</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>qtgui_tab_widget</key>
<param><key>id</key><value>pestana</value></param>
<param><key>gui_hint</key><value>3,0,1,4</value></param>
<param><key>label0</key><value>Tiempo</value></param>
<param><key>label1</key><value>Constelacion</value></param>
<param><key>label2</key><value>Espectro</value></param>
<param><key>label3</key><value>Tunner</value></param>
<param><key>num_tabs</key><value>4</value></param>
</block>
<block>
<key>qtgui_const_sink_x</key>
<param><key>id</key><value>qtgui_const_sink_x_0_0_0</value></param>
<param><key>gui_hint</key><value>pestana@3:2,0,1,1</value></param>
<param><key>label1</key><value>Rx</value></param>
<param><key>name</key><value>"Rx canal"</value></param>
<param><key>nconnections</key><value>2</value></param>
<param><key>size</key><value>1024</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>xmax</key><value>0.2</value></param>
<param><key>xmin</key><value>-0.2</value></param>
<param><key>ymax</key><value>0.2</value></param>
<param><key>ymin</key><value>-0.2</value></param>
</block>
<block>
<key>qtgui_const_sink_x</key>
<param><key>id</key><value>qtgui_const_sink_x_0_0_0_0</value></param>
<param><key>gui_hint</key><value>pestana@3:2,1,1,1</value></param>
<param><key>label1</key><value>Rx</value></param>
<param><key>name</key><value>"Rx sampled"</value></param>
<param><key>size</key><value>1024</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>xmax</key><value>0.2</value></param>
<param><key>xmin</key><value>-0.2</value></param>
<param><key>ymax</key><value>0.2</value></param>
<param><key>ymin</key><value>-0.2</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_1_1_0_0_0</value></param>
<param><key>gui_hint</key><value>pestana@3:3,0,1,2</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value>Rx I</value></param>
<param><key>color2</key><value>"red"</value></param>
<param><key>label2</key><value>Rx Q</value></param>
<param><key>color3</key><value>"green"</value></param>
<param><key>label3</key><value></value></param>
<param><key>color4</key><value>"black"</value></param>
<param><key>label4</key><value></value></param>
<param><key>name</key><value>"Rx Sample Tunning"</value></param>
<param><key>nconnections</key><value>2</value></param>
<param><key>size</key><value>Nscope_span*sps</value></param>
<param><key>srate</key><value>samp_rate</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>ymax</key><value>0.5</value></param>
<param><key>ymin</key><value>-0.5</value></param>
</block>
<connection><source_block_id>b_sampler_cc_0</source_block_id><sink_block_id>qtgui_const_sink_x_0_0_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>b_sampler_cc_0</source_block_id><sink_block_id>qtgui_time_sink_x_1_1_0_0_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>b_sampler_cc_0</source_block_id><sink_block_id>pad_sink_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>b_sampler_cc_0</source_block_id><sink_block_id>qtgui_const_sink_x_0_0_0_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>b_tunner_0</source_block_id><sink_block_id>b_sampler_cc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>b_tunner_0</source_block_id><sink_block_id>qtgui_time_sink_x_1_1_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pad_source_0</source_block_id><sink_block_id>b_tunner_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pad_source_0</source_block_id><sink_block_id>qtgui_const_sink_x_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
