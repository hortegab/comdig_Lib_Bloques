<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.13'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>b_USRP_2_USRP_v2</value></param>
<param><key>author</key><value>Homero Ortega Boada. Universidad Industrial de Santander</value></param>
<param><key>category</key><value>comdiguis</value></param>
<param><key>description</key><value>Este bloque es el simulador de un canal inalambrico que incluye 2 USRPs, uno en la parte transmisora y otro en la receptora. Se puede usar cuando no se tengan USRP fisicos a la mano. Parametros usados: samp_rate_Tx (Hz) es la frecuencia de muestreo del USRP transmisor; Bandwidth_Tx  (Hz) ancho de banda programado en el USRP transmisor; Center freq Tx (Hz) frecuencia central del USRP Transmisor; samp_rate_Rx, Bandwidth_Rx, Center freq Rx  son equivalentes a los anteriores pero para el USRP receptor;  Toffset (numero de muestras de offset. como la rata de muestras de la senal entrante puede ser diferente a la saliente, en este caso se toman de la senal entrante) permtite programar un tiempo de retardo de la senal en propagacion;  Phoffset (Rad) permite programar una desviacion entre el angulo de la portadora usada en transmision y la usada en recepcion; No (dB) es el valor No (o PSD) dado en decibeles del ruido blanco del canal; Katt (en dB de potencia) nivel de atenuacion que la senal transmitida sufre en el proceso de propagacion. </value></param>
<param><key>generate_options</key><value>hb</value></param>
<param><key>title</key><value>b_USRP_2_USRP_v2</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>B_Rxx</value></param>
<param><key>value</key><value>(Rx_B&gt;0)*Rx_B+(Rx_B==0)*Rx__samp_rate</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>B_Txx</value></param>
<param><key>value</key><value>(Tx_B&gt;0)*Tx_B+(Tx_B==0)*Tx__samp_rate</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>Bmin</value></param>
<param><key>value</key><value>min(B_Txx, B_Rxx)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>Foffset</value></param>
<param><key>value</key><value>Tx_Fc-Rx_Fc</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>Gain_Rx</value></param>
<param><key>value</key><value>math.pow(10, Rx_Gain_dB/20.)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>Gain_Tx_Loss</value></param>
<param><key>value</key><value>math.pow(10, Gain_Tx_Loss_dB/20.)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>Gain_Tx_Loss_dB</value></param>
<param><key>value</key><value>Tx_Gain_dB  - Ch_Loss_dB</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>Ch_Loss_dB</value></param>
<param><key>label</key><value>Channel Attenuation (dB)</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>10.</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>Ch_NodB</value></param>
<param><key>label</key><value>Channel White Noise (No in dB)</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>1000</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>Ch_Phoffset</value></param>
<param><key>label</key><value>Channel Angle Offset</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>(numpy.pi)*2*random.random()</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>Ch_Toffset</value></param>
<param><key>label</key><value>Channel Toffset</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>5</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>Note</value></param>
<param><key>note</key><value>Por mejorar:  1) no se tiene en cuenta el filtrado 2) si la frecuencia de muestreo del transmisor y receptor son diferentes saldria error, pues los elementos despues del rational resampler no estan ajustados a la frecuencia de ese bloque  3) El hardware y software interno del USR tienen limitaciones que no son tenidas en cuenta aqui como: los amplificadores de los USRP tienen valores limitados 2) El cuantizador del tiene un rango dinamico definido, el decimador esta limitado a ciertos coeficientes. Una mejora, deberia incluir un simulador de los bloques que tienen que ver con esos parametros.</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>Rx_B</value></param>
<param><key>label</key><value>Rx Bandwidth (Hz)</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>1000</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>Rx_Fc</value></param>
<param><key>label</key><value>Rx Center Freq (Hz)</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>200000000</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>Rx_Gain_dB</value></param>
<param><key>label</key><value>Rx_Gain_dB</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>10.</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>Rx__samp_rate</value></param>
<param><key>label</key><value>Rx_samp_rate (int)</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>1000</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>Tx_B</value></param>
<param><key>label</key><value>Tx_Bandwidth (Hz)</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>1000</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>Tx_Fc</value></param>
<param><key>label</key><value>Tx Center Freq(Hz)</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>200000000</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>Tx_Gain_dB</value></param>
<param><key>label</key><value>Tx_Gain_dB</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>10.</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>Tx__samp_rate</value></param>
<param><key>label</key><value>Tx_samp_rate (int)</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>1000</value></param>
</block>
<block>
<key>analog_const_source_x</key>
<param><key>id</key><value>analog_const_source_x_1_0</value></param>
<param><key>const</key><value>cmath.exp(1j * Ch_Phoffset)</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>analog_sig_source_x</key>
<param><key>id</key><value>analog_sig_source_x_0</value></param>
<param><key>amp</key><value>1</value></param>
<param><key>freq</key><value>Foffset</value></param>
<param><key>offset</key><value>0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>samp_rate</key><value>Rx__samp_rate</value></param>
<param><key>waveform</key><value>analog.GR_COS_WAVE</value></param>
</block>
<block>
<key>b_noise_dB_cc</key>
<param><key>id</key><value>b_noise_dB_cc_0</value></param>
<param><key>NodB</key><value>Ch_NodB</value></param>
<param><key>samp_rate</key><value>10000</value></param>
</block>
<block>
<key>blocks_add_xx</key>
<param><key>id</key><value>blocks_add_xx_0</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_delay</key>
<param><key>id</key><value>blocks_delay_0</value></param>
<param><key>delay</key><value>Ch_Toffset</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_0</value></param>
<param><key>const</key><value>Gain_Tx_Loss+0j</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_0_0</value></param>
<param><key>const</key><value>Gain_Rx+0j</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_multiply_xx</key>
<param><key>id</key><value>blocks_multiply_xx_0</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_multiply_xx</key>
<param><key>id</key><value>blocks_multiply_xx_0_0</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0_1</value></param>
<param><key>import</key><value>import cmath</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0_1_0</value></param>
<param><key>import</key><value>import numpy</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0_1_0_0</value></param>
<param><key>import</key><value>import random</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0_1_1</value></param>
<param><key>import</key><value>import math</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>pad_sink_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>label</key><value>out</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>pad_sink_0_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>label</key><value>Noise</value></param>
<param><key>optional</key><value>True</value></param>
</block>
<block>
<key>pad_source</key>
<param><key>id</key><value>pad_source_0</value></param>
<param><key>label</key><value>in</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>rational_resampler_xxx</key>
<param><key>id</key><value>rational_resampler_xxx_0</value></param>
<param><key>decim</key><value>int(Tx__samp_rate)</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>interp</key><value>int(Rx__samp_rate)</value></param>
<param><key>taps</key><value></value></param>
<param><key>type</key><value>ccc</value></param>
</block>
<connection><source_block_id>analog_const_source_x_1_0</source_block_id><sink_block_id>blocks_multiply_xx_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>analog_sig_source_x_0</source_block_id><sink_block_id>blocks_multiply_xx_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>b_noise_dB_cc_0</source_block_id><sink_block_id>blocks_add_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>b_noise_dB_cc_0</source_block_id><sink_block_id>pad_sink_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_add_xx_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_delay_0</source_block_id><sink_block_id>blocks_multiply_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_delay_0</source_block_id><sink_block_id>rational_resampler_xxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0</source_block_id><sink_block_id>blocks_delay_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0_0</source_block_id><sink_block_id>pad_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_xx_0</source_block_id><sink_block_id>blocks_multiply_xx_0_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_multiply_xx_0_0</source_block_id><sink_block_id>blocks_add_xx_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>pad_source_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rational_resampler_xxx_0</source_block_id><sink_block_id>blocks_multiply_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
