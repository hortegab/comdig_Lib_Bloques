<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.9'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>b_cdma_cc</value></param>
<param><key>author</key><value>Homero Ortega Boada. Universidad Industrial de Santander</value></param>
<param><key>category</key><value>borrar</value></param>
<param><key>generate_options</key><value>hb</value></param>
<param><key>title</key><value>b_cdma</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>N</value></param>
<param><key>value</key><value>8</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>SF</value></param>
<param><key>label</key><value>SF</value></param>
<param><key>value</key><value>8</value></param>
</block>
<block>
<key>b_ds_spreadspect_cc</key>
<param><key>id</key><value>b_ds_spreadspect_cc_0</value></param>
<param><key>SF</key><value>8</value></param>
<param><key>codigo</key><value>c0</value></param>
</block>
<block>
<key>b_ds_spreadspect_cc</key>
<param><key>id</key><value>b_ds_spreadspect_cc_0_0</value></param>
<param><key>SF</key><value>8</value></param>
<param><key>codigo</key><value>c1</value></param>
</block>
<block>
<key>b_ds_spreadspect_cc</key>
<param><key>id</key><value>b_ds_spreadspect_cc_0_0_0</value></param>
<param><key>SF</key><value>8</value></param>
<param><key>codigo</key><value>c2</value></param>
</block>
<block>
<key>b_ds_spreadspect_cc</key>
<param><key>id</key><value>b_ds_spreadspect_cc_0_0_1</value></param>
<param><key>SF</key><value>8</value></param>
<param><key>codigo</key><value>c3</value></param>
</block>
<block>
<key>b_ds_spreadspect_cc</key>
<param><key>id</key><value>b_ds_spreadspect_cc_0_0_2</value></param>
<param><key>SF</key><value>8</value></param>
<param><key>codigo</key><value>c4</value></param>
</block>
<block>
<key>b_ds_spreadspect_cc</key>
<param><key>id</key><value>b_ds_spreadspect_cc_0_0_3</value></param>
<param><key>SF</key><value>8</value></param>
<param><key>codigo</key><value>c5</value></param>
</block>
<block>
<key>b_ds_spreadspect_cc</key>
<param><key>id</key><value>b_ds_spreadspect_cc_0_0_4</value></param>
<param><key>SF</key><value>8</value></param>
<param><key>codigo</key><value>c6</value></param>
</block>
<block>
<key>b_ds_spreadspect_cc</key>
<param><key>id</key><value>b_ds_spreadspect_cc_0_0_5</value></param>
<param><key>SF</key><value>8</value></param>
<param><key>codigo</key><value>c7</value></param>
</block>
<block>
<key>blocks_add_xx</key>
<param><key>id</key><value>blocks_add_xx_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>num_inputs</key><value>8</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>c0</value></param>
<param><key>label</key><value>c0</value></param>
<param><key>value</key><value>(0+0j,0+0j,0+0j)</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>c1</value></param>
<param><key>label</key><value>c1</value></param>
<param><key>value</key><value>(0+0j,0+0j,0+0j)</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>c2</value></param>
<param><key>label</key><value>c2</value></param>
<param><key>value</key><value>(0+0j,0+0j,0+0j)</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>c3</value></param>
<param><key>label</key><value>c3</value></param>
<param><key>value</key><value>(0+0j,0+0j,0+0j)</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>c4</value></param>
<param><key>label</key><value>c4</value></param>
<param><key>value</key><value>(0+0j,0+0j,0+0j)</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>c5</value></param>
<param><key>label</key><value>c5</value></param>
<param><key>value</key><value>(0+0j,0+0j,0+0j)</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>c6</value></param>
<param><key>label</key><value>c6</value></param>
<param><key>value</key><value>(0+0j,0+0j,0+0j)</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>c7</value></param>
<param><key>label</key><value>c7</value></param>
<param><key>value</key><value>(0+0j,0+0j,0+0j)</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0</value></param>
<param><key>import</key><value>import math</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0_1</value></param>
<param><key>import</key><value>import cmath</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0_1_0</value></param>
<param><key>import</key><value>import numpy</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>info</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>label</key><value>infode us1</value></param>
<param><key>optional</key><value>True</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>pad_sink_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>label</key><value>out</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>pad_sink_0_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>label</key><value>cod de us1</value></param>
<param><key>optional</key><value>True</value></param>
</block>
<block>
<key>pad_source</key>
<param><key>id</key><value>pad_source_0</value></param>
<param><key>label</key><value>in0</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>pad_source</key>
<param><key>id</key><value>pad_source_1</value></param>
<param><key>label</key><value>in1</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>pad_source</key>
<param><key>id</key><value>pad_source_2</value></param>
<param><key>label</key><value>in2</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>pad_source</key>
<param><key>id</key><value>pad_source_3</value></param>
<param><key>label</key><value>in3</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>pad_source</key>
<param><key>id</key><value>pad_source_4</value></param>
<param><key>label</key><value>in4</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>pad_source</key>
<param><key>id</key><value>pad_source_5</value></param>
<param><key>label</key><value>in5</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>pad_source</key>
<param><key>id</key><value>pad_source_6</value></param>
<param><key>label</key><value>in6</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>pad_source</key>
<param><key>id</key><value>pad_source_7</value></param>
<param><key>label</key><value>in7</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<connection><source_block_id>b_ds_spreadspect_cc_0</source_block_id><sink_block_id>blocks_add_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>b_ds_spreadspect_cc_0_0</source_block_id><sink_block_id>pad_sink_0_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>b_ds_spreadspect_cc_0_0</source_block_id><sink_block_id>info</sink_block_id><source_key>2</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>b_ds_spreadspect_cc_0_0</source_block_id><sink_block_id>blocks_add_xx_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>b_ds_spreadspect_cc_0_0_0</source_block_id><sink_block_id>blocks_add_xx_0</sink_block_id><source_key>0</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>b_ds_spreadspect_cc_0_0_1</source_block_id><sink_block_id>blocks_add_xx_0</sink_block_id><source_key>0</source_key><sink_key>3</sink_key></connection>
<connection><source_block_id>b_ds_spreadspect_cc_0_0_2</source_block_id><sink_block_id>blocks_add_xx_0</sink_block_id><source_key>0</source_key><sink_key>4</sink_key></connection>
<connection><source_block_id>b_ds_spreadspect_cc_0_0_3</source_block_id><sink_block_id>blocks_add_xx_0</sink_block_id><source_key>0</source_key><sink_key>5</sink_key></connection>
<connection><source_block_id>b_ds_spreadspect_cc_0_0_4</source_block_id><sink_block_id>blocks_add_xx_0</sink_block_id><source_key>0</source_key><sink_key>6</sink_key></connection>
<connection><source_block_id>b_ds_spreadspect_cc_0_0_5</source_block_id><sink_block_id>blocks_add_xx_0</sink_block_id><source_key>0</source_key><sink_key>7</sink_key></connection>
<connection><source_block_id>blocks_add_xx_0</source_block_id><sink_block_id>pad_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pad_source_0</source_block_id><sink_block_id>b_ds_spreadspect_cc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pad_source_1</source_block_id><sink_block_id>b_ds_spreadspect_cc_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pad_source_2</source_block_id><sink_block_id>b_ds_spreadspect_cc_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pad_source_3</source_block_id><sink_block_id>b_ds_spreadspect_cc_0_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pad_source_4</source_block_id><sink_block_id>b_ds_spreadspect_cc_0_0_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pad_source_5</source_block_id><sink_block_id>b_ds_spreadspect_cc_0_0_3</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pad_source_6</source_block_id><sink_block_id>b_ds_spreadspect_cc_0_0_4</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pad_source_7</source_block_id><sink_block_id>b_ds_spreadspect_cc_0_0_5</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
