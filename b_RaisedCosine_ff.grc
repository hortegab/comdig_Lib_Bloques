<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.9'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>b_Raised_cosine_ff</value></param>
<param><key>author</key><value>Done by: Homero Ortega Boada. Universidad Industrial de Santander.</value></param>
<param><key>category</key><value>comdiguis</value></param>
<param><key>description</key><value>It is the float type version of the Raised Cosine Filter. Usually gnuradio comes with the square root variant, but this is the right one . You can introduce the rolloff factor (rolloff), the number of samples you want the filter produce at the output per each input symbol (sps) and of course, the number of components to take into account in the impulse response of the filter (ntaps)</value></param>
<param><key>generate_options</key><value>hb</value></param>
<param><key>title</key><value>b_Raised_cosine_ff</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>ntaps</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>16</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>pad_sink_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>label</key><value>out</value></param>
</block>
<block>
<key>pad_source</key>
<param><key>id</key><value>pad_source_0</value></param>
<param><key>label</key><value>in</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>rolloff</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>1</value></param>
</block>
<block>
<key>root_raised_cosine_filter</key>
<param><key>id</key><value>root_raised_cosine_filter_0</value></param>
<param><key>alpha</key><value>rolloff</value></param>
<param><key>type</key><value>interp_fir_filter_fff</value></param>
<param><key>gain</key><value>2</value></param>
<param><key>interp</key><value>sps</value></param>
<param><key>ntaps</key><value>ntaps</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>sym_rate</key><value>samp_rate/sps</value></param>
</block>
<block>
<key>root_raised_cosine_filter</key>
<param><key>id</key><value>root_raised_cosine_filter_0_0</value></param>
<param><key>alpha</key><value>rolloff</value></param>
<param><key>type</key><value>interp_fir_filter_fff</value></param>
<param><key>gain</key><value>2</value></param>
<param><key>interp</key><value>1</value></param>
<param><key>ntaps</key><value>ntaps</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>sym_rate</key><value>samp_rate/sps</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>1000</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>sps</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>8</value></param>
</block>
<connection><source_block_id>pad_source_0</source_block_id><sink_block_id>root_raised_cosine_filter_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>root_raised_cosine_filter_0</source_block_id><sink_block_id>root_raised_cosine_filter_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>root_raised_cosine_filter_0_0</source_block_id><sink_block_id>pad_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
