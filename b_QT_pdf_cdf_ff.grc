<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.13'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>b_pdf_cdf_ff</value></param>
<param><key>author</key><value>Homero Ortega Boada. Universidad Industrial de Santander</value></param>
<param><key>category</key><value>comdiguis</value></param>
<param><key>description</key><value>Hecho por Homero Ortega. Recibe an input with values between Xmin and Xmax and calculate the Probaility Density Function (PDF), as well as Cumulative Distribution Function (CDF) dinamically.</value></param>
<param><key>generate_options</key><value>hb_qt_gui</value></param>
<param><key>title</key><value>b_pdf_cdf_ff</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>N</value></param>
<param><key>value</key><value>1024</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>step</value></param>
<param><key>value</key><value>float(Xmax-Xmin)/N</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>EjeX</value></param>
<param><key>label</key><value>Nombre Eje Horiz</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value>'potencia'</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>Note</value></param>
<param><key>note</key><value>Esta ramificacion de abajo es la que introduce las fluctuaciones en magnitud</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>Xmax</value></param>
<param><key>label</key><value>Xmax</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>4.</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>Xmin</value></param>
<param><key>label</key><value>Xmin</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>-4.</value></param>
</block>
<block>
<key>blocks_stream_to_vector</key>
<param><key>id</key><value>blocks_stream_to_vector_0_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>num_items</key><value>N</value></param>
</block>
<block>
<key>epy_block</key>
<param><key>id</key><value>e_vector_integrate_ff</value></param>
<param><key>_source_code</key><value>"""
Embedded Python Blocks:

Each time this file is saved, GRC will instantiate the first class it finds
to get ports and parameters of your block. The arguments to __init__  will
be the parameters. All of them are required to have default values!
"""

import numpy as np
from gnuradio import gr
from scipy import integrate

class e_vector_integrate_ff(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
    """Hecho por Homero Ortega. Integrates de input signal en the lenght N of the vector. step is the distance between samples. So that every N samples integration is reset"""

    def __init__(self, step=0.01, N=1024):  # only default arguments here
        gr.sync_block.__init__(
            self,
            name='e_vector_integrate_ff',   # will show up in GRC
            in_sig=[(np.float32, N)],
            out_sig=[(np.float32,N)]
        )
	self.N = N
	self.step = step

    def work(self, input_items, output_items):
        output_items[0][:]=integrate.cumtrapz(input_items[0],dx=self.step,initial=0)
        # print("dx=",self.step)
        return len(output_items[0])

</value></param>
<param><key>N</key><value>N</value></param>
<param><key>step</key><value>step</value></param>
</block>
<block>
<key>pad_source</key>
<param><key>id</key><value>pad_source_0</value></param>
<param><key>label</key><value>in</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>epy_block</key>
<param><key>id</key><value>pdf2_ff</value></param>
<param><key>_source_code</key><value>"""
Embedded Python Blocks:

Each time this file is saved, GRC will instantiate the first class it finds
to get ports and parameters of your block. The arguments to __init__  will
be the parameters. All of them are required to have default values!
"""

import numpy as np
from gnuradio import gr
from scipy import integrate
import scipy.stats

class e_pdf2_ff(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
    """Hecho por Homero Ortega. Xmin is the minimum value that the input signal can take, Xmax is the maximum value that the input signal can take; N es the number of steps the signal will be analized in amplitud and is the number of samples for the histogram"""

    def __init__(self, Xmin=-1., Xmax=1., N=1024):  # only default arguments here
        gr.sync_block.__init__(
            self,
            name='e_pdf2_ff',   # will show up in GRC
            in_sig=[(np.float32, N)],
            out_sig=[(np.float32,N)]
        )
        self.Xmin = Xmin
	self.Xmax = Xmax
	self.N = N
        self.X=np.linspace(self.Xmin,self.Xmax,self.N) # Se le pueden dar menos valores, pero el bloque seria de tipo decimador
        self.counts=np.array([0.]*self.N)
        self.N_hist=0. #numero de histogramas procesados
        
    def work(self, input_items, output_items):
        
        x=input_items[0] # las muestras entrantes a analizar
        h=np.histogram(x,bins=self.N, range=(self.Xmin, self.Xmax)) # h[0] es el histograma propiamente, h[1] los bins
        hist_dist=scipy.stats.rv_histogram(h) # objeto que identifica muchos parametros de un histograma incluyento pdf
        pdf=hist_dist.pdf(self.X) # es la pdf instantanea (del vector actual)

        # cdf=hist_dist.cdf(self.X) # Este seria el comando si necesitamos cdf en vez de pdf

        self.N_hist += 1     # se eleva el contador de histrogramas calculados
        self.counts += pdf  # pdf acumulada
        output_items[0][:]=self.counts/(self.N_hist)   # pdf promediada

        return len(output_items[0])
</value></param>
<param><key>N</key><value>N</value></param>
<param><key>Xmax</key><value>Xmax</value></param>
<param><key>Xmin</key><value>Xmin</value></param>
</block>
<block>
<key>epy_block</key>
<param><key>id</key><value>pdf_ff</value></param>
<param><key>_source_code</key><value>"""
Embedded Python Blocks:

Each time this file is saved, GRC will instantiate the first class it finds
to get ports and parameters of your block. The arguments to __init__  will
be the parameters. All of them are required to have default values!
"""

import numpy as np
from gnuradio import gr
from scipy import integrate

class e_pdf_ff(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
    """Hecho por Homero Ortega. Xmin is the minimum value that the input signal can take, Xmax is the maximum value that the input signal can take; N es the number of steps the signal will be analized in amplitud and is the number of samples for the histogram"""

    def __init__(self, Xmin=-1., Xmax=1., N=1024):  # only default arguments here
        gr.sync_block.__init__(
            self,
            name='e_pdf_ff',   # will show up in GRC
            in_sig=[(np.float32, N)],
            out_sig=[(np.float32,N)]
        )
        self.Xmin = Xmin
	self.Xmax = Xmax
	self.N = N
        self.counts=np.array([0]*self.N)
        self.N_hist=0. #numero de histogramas procesados
        self.step=float(Xmax-Xmin)/N

    def work(self, input_items, output_items):
        out0=output_items[0]
        x=input_items[0] # las muestras entrantes a analizar
        h=np.histogram(x,bins=self.N, range=(self.Xmin, self.Xmax))
        self.N_hist += 1
        self.counts += h[0] # h es una matrix, el histograma esta en h[0]
        pdf=self.counts/(self.N_hist*self.N) # propability density function
        out0[:]=pdf
        return len(output_items[0])
</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>N</key><value>N</value></param>
<param><key>Xmax</key><value>Xmax</value></param>
<param><key>Xmin</key><value>Xmin</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>pdf_max</value></param>
<param><key>label</key><value>pdf_max</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>0.025</value></param>
</block>
<block>
<key>qtgui_vector_sink_f</key>
<param><key>id</key><value>qtgui_vector_sink_f_0_0</value></param>
<param><key>width1</key><value>3</value></param>
<param><key>name</key><value>"Cumulative Distribution Function (CDF )"</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>vlen</key><value>N</value></param>
<param><key>x_axis_label</key><value>EjeX</value></param>
<param><key>x_start</key><value>Xmin</value></param>
<param><key>x_step</key><value>step</value></param>
<param><key>ymax</key><value>1.</value></param>
<param><key>ymin</key><value>0.</value></param>
<param><key>y_axis_label</key><value>"PDF"</value></param>
</block>
<block>
<key>qtgui_vector_sink_f</key>
<param><key>id</key><value>qtgui_vector_sink_f_0_0_0</value></param>
<param><key>autoscale</key><value>True</value></param>
<param><key>width1</key><value>3</value></param>
<param><key>name</key><value>"Probability Density Function (PDF)"</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>vlen</key><value>N</value></param>
<param><key>x_axis_label</key><value>EjeX</value></param>
<param><key>x_start</key><value>Xmin</value></param>
<param><key>x_step</key><value>(Xmax-Xmin)/N</value></param>
<param><key>ymax</key><value>pdf_max</value></param>
<param><key>ymin</key><value>0.</value></param>
<param><key>y_axis_label</key><value>"PDF"</value></param>
</block>
<connection><source_block_id>blocks_stream_to_vector_0_0</source_block_id><sink_block_id>pdf2_ff</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>e_vector_integrate_ff</source_block_id><sink_block_id>qtgui_vector_sink_f_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pad_source_0</source_block_id><sink_block_id>blocks_stream_to_vector_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pdf2_ff</source_block_id><sink_block_id>e_vector_integrate_ff</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pdf2_ff</source_block_id><sink_block_id>qtgui_vector_sink_f_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
