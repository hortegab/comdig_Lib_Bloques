<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.13'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>b_BERTool_ff</value></param>
<param><key>author</key><value>Homero Ortega Boada</value></param>
<param><key>category</key><value>comdiguis</value></param>
<param><key>description</key><value>Este Bloque sirve a la vez como canal de Ruido Blanco Gausiano y como herramienta para calcular la curva de BER (Bit error Rate) para una senal binaria real. Pero tambien se puede usar para señales M-arias reales como M-PAM. Se pueden usar señales que han pasado por un filtroformador de pulsos. En caso de que la entrada sea una señal binara, siempre que se hable de simbolos es lo mismo que hablar de bits, es decir, los simbolos son bits puros. Parametros usados: Sps - es el número muestras por simbolo, en caso de no usar un filtro formador de pulsos Sps=1, recuerde que Sps=samp_reate/Sps; Rs - es la rata de simbolos; N_snr - numero de puntos que tendra la curva de BER; EsNomin: valor minimo de la relación Es/No; EsNomax: valor máximo de la relacion Es/No. Las señales de entrada son: in Tx  para los  simbolos transmitidos; in Rx  para los simbolos recibidos; in es la señal enviada. La salida son dos senales: out - es la Curva de BER o SER a graficar;  out_env - es la señal que sale del canal AWGN, que es la misma entrante pero con ruido ; out que son los valores de BER o SER disponibles. IMPORTANTE: que la curva sea BER o sea SER lo define el tipo de senal que se tiene en in Tx y en in Rx, donde se tiene en cada caso una senal M-aria. Asi que si M=2, estamos enviando y recibiendo simbolos, luego obtenemos curva de BER, pero si M&gt;2 estamos hablando de curva de SER.</value></param>
<param><key>generate_options</key><value>hb</value></param>
<param><key>title</key><value>b_BERTool_ff</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>B</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>label</key><value>B</value></param>
<param><key>value</key><value>128</value></param>
</block>
<block>
<key>E3TRadio_e_BERtool</key>
<param><key>id</key><value>E3TRadio_e_BERtool_0</value></param>
<param><key>N</key><value>N_snr</value></param>
</block>
<block>
<key>E3TRadio_e_canal_BER</key>
<param><key>id</key><value>E3TRadio_e_canal_BER_0</value></param>
<param><key>B</key><value>Rs*Sps</value></param>
<param><key>EsN0max</key><value>EsN0max/2.</value></param>
<param><key>EsN0min</key><value>EsN0min/2.</value></param>
<param><key>N</key><value>N_snr</value></param>
<param><key>Rs</key><value>Rs</value></param>
</block>
<block>
<key>E3TRadio_zero_order_hold_bb</key>
<param><key>id</key><value>E3TRadio_zero_order_hold_bb_0</value></param>
<param><key>k</key><value>Sps</value></param>
</block>
<block>
<key>E3TRadio_zero_order_hold_bb</key>
<param><key>id</key><value>E3TRadio_zero_order_hold_bb_0_0</value></param>
<param><key>k</key><value>Sps</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>EsN0max</value></param>
<param><key>label</key><value>EsN0max</value></param>
<param><key>value</key><value>20</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>EsN0min</value></param>
<param><key>label</key><value>EsN0min</value></param>
<param><key>value</key><value>0</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>N_snr</value></param>
<param><key>label</key><value>N_snr</value></param>
<param><key>value</key><value>128</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>Rs</value></param>
<param><key>label</key><value>Rs</value></param>
<param><key>value</key><value>125</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>Sps</value></param>
<param><key>label</key><value>Sps</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>1</value></param>
</block>
<block>
<key>blocks_complex_to_float</key>
<param><key>id</key><value>blocks_complex_to_float_0</value></param>
</block>
<block>
<key>blocks_float_to_complex</key>
<param><key>id</key><value>blocks_float_to_complex_0</value></param>
</block>
<block>
<key>blocks_nlog10_ff</key>
<param><key>id</key><value>blocks_nlog10_ff_0</value></param>
<param><key>k</key><value>0</value></param>
</block>
<block>
<key>blocks_null_sink</key>
<param><key>id</key><value>blocks_null_sink_0</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_null_source</key>
<param><key>id</key><value>blocks_null_source_0</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_stream_to_vector</key>
<param><key>id</key><value>blocks_stream_to_vector_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>num_items</key><value>N_snr</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_0</value></param>
<param><key>note</key><value>NOTA PARA MEJORAR ESTE BLOQUE. Se proponen las siguientes modificaciones; 1) mejorar el canal para que tenga dos entradas, una para la señal modulada, otra para recibir el monto de ruido requerido (No o Pn o Es/No o SNR) 2) complementar  el e_BERToll  para que asuma el roll de ordenar la SNR requerida. 3) optimizar e_BERToll para que haga promediados más largos y enfatice en los valors SNR que sean más relevantes, evitando con ello recalcular parte de las curvas que van quedando bien definidas y concentrandose donde no están tan definidas.</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>pad_sink_0_0_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>label</key><value>out_env</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>pad_sink_0_0_0_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>label</key><value>out</value></param>
<param><key>vlen</key><value>N_snr</value></param>
</block>
<block>
<key>pad_source</key>
<param><key>id</key><value>pad_source_0_0</value></param>
<param><key>label</key><value>in</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>pad_source</key>
<param><key>id</key><value>pad_source_0_0_0</value></param>
<param><key>label</key><value>in_Tx</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>pad_source</key>
<param><key>id</key><value>pad_source_0_0_0_0</value></param>
<param><key>label</key><value>in_Rx</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>tipo_mod</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>label</key><value>tipo_mod</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value>"QPSK"</value></param>
</block>
<connection><source_block_id>E3TRadio_e_BERtool_0</source_block_id><sink_block_id>blocks_nlog10_ff_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>E3TRadio_e_canal_BER_0</source_block_id><sink_block_id>blocks_complex_to_float_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>E3TRadio_e_canal_BER_0</source_block_id><sink_block_id>E3TRadio_e_BERtool_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>E3TRadio_zero_order_hold_bb_0</source_block_id><sink_block_id>E3TRadio_e_BERtool_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>E3TRadio_zero_order_hold_bb_0_0</source_block_id><sink_block_id>E3TRadio_e_BERtool_0</sink_block_id><source_key>0</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>blocks_complex_to_float_0</source_block_id><sink_block_id>blocks_null_sink_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_float_0</source_block_id><sink_block_id>pad_sink_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_float_to_complex_0</source_block_id><sink_block_id>E3TRadio_e_canal_BER_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_nlog10_ff_0</source_block_id><sink_block_id>blocks_stream_to_vector_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_null_source_0</source_block_id><sink_block_id>blocks_float_to_complex_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_stream_to_vector_0</source_block_id><sink_block_id>pad_sink_0_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pad_source_0_0</source_block_id><sink_block_id>blocks_float_to_complex_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pad_source_0_0_0</source_block_id><sink_block_id>E3TRadio_zero_order_hold_bb_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pad_source_0_0_0_0</source_block_id><sink_block_id>E3TRadio_zero_order_hold_bb_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
