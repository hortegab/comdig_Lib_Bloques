<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.9'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>b_de_cdma_cc</value></param>
<param><key>author</key><value>Homero Ortega Boada. Universidad Industrial de Santander</value></param>
<param><key>category</key><value>comdiguis</value></param>
<param><key>generate_options</key><value>hb</value></param>
<param><key>title</key><value>b_de_cdma_cc</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>g</value></param>
<param><key>value</key><value>8</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>ChipsSysDelay</value></param>
<param><key>label</key><value>ChipsSysDelay</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>0</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>SF</value></param>
<param><key>label</key><value>SF</value></param>
<param><key>value</key><value>8</value></param>
</block>
<block>
<key>b_de_ds_spreadspect_cc</key>
<param><key>id</key><value>b_de_ds_spreadspect_cc_0</value></param>
<param><key>ChipsSysDelay</key><value>ChipsSysDelay</value></param>
<param><key>SF</key><value>SF</value></param>
<param><key>codigo</key><value>c0</value></param>
</block>
<block>
<key>b_de_ds_spreadspect_cc</key>
<param><key>id</key><value>b_de_ds_spreadspect_cc_0_0</value></param>
<param><key>ChipsSysDelay</key><value>ChipsSysDelay</value></param>
<param><key>SF</key><value>SF</value></param>
<param><key>codigo</key><value>c1</value></param>
</block>
<block>
<key>b_de_ds_spreadspect_cc</key>
<param><key>id</key><value>b_de_ds_spreadspect_cc_0_2</value></param>
<param><key>ChipsSysDelay</key><value>ChipsSysDelay</value></param>
<param><key>SF</key><value>SF</value></param>
<param><key>codigo</key><value>c7</value></param>
</block>
<block>
<key>b_de_ds_spreadspect_cc</key>
<param><key>id</key><value>b_de_ds_spreadspect_cc_0_3</value></param>
<param><key>ChipsSysDelay</key><value>ChipsSysDelay</value></param>
<param><key>SF</key><value>SF</value></param>
<param><key>codigo</key><value>c6</value></param>
</block>
<block>
<key>b_de_ds_spreadspect_cc</key>
<param><key>id</key><value>b_de_ds_spreadspect_cc_0_4</value></param>
<param><key>ChipsSysDelay</key><value>ChipsSysDelay</value></param>
<param><key>SF</key><value>SF</value></param>
<param><key>codigo</key><value>c5</value></param>
</block>
<block>
<key>b_de_ds_spreadspect_cc</key>
<param><key>id</key><value>b_de_ds_spreadspect_cc_0_5</value></param>
<param><key>ChipsSysDelay</key><value>ChipsSysDelay</value></param>
<param><key>SF</key><value>SF</value></param>
<param><key>codigo</key><value>c4</value></param>
</block>
<block>
<key>b_de_ds_spreadspect_cc</key>
<param><key>id</key><value>b_de_ds_spreadspect_cc_0_6</value></param>
<param><key>ChipsSysDelay</key><value>ChipsSysDelay</value></param>
<param><key>SF</key><value>SF</value></param>
<param><key>codigo</key><value>c3</value></param>
</block>
<block>
<key>b_de_ds_spreadspect_cc</key>
<param><key>id</key><value>b_de_ds_spreadspect_cc_0_7</value></param>
<param><key>ChipsSysDelay</key><value>ChipsSysDelay</value></param>
<param><key>SF</key><value>SF</value></param>
<param><key>codigo</key><value>c2</value></param>
</block>
<block>
<key>blocks_null_sink</key>
<param><key>id</key><value>blocks_null_sink_0</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>num_inputs</key><value>12</value></param>
</block>
<block>
<key>blocks_null_sink</key>
<param><key>id</key><value>blocks_null_sink_1</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>num_inputs</key><value>16</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>c0</value></param>
<param><key>label</key><value>c0</value></param>
<param><key>value</key><value>(0+0j,0+0j,0+0j)</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>c1</value></param>
<param><key>label</key><value>c1</value></param>
<param><key>value</key><value>(0+0j,0+0j,0+0j)</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>c2</value></param>
<param><key>label</key><value>c2</value></param>
<param><key>value</key><value>(0+0j,0+0j,0+0j)</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>c3</value></param>
<param><key>label</key><value>c3</value></param>
<param><key>value</key><value>(0+0j,0+0j,0+0j)</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>c4</value></param>
<param><key>label</key><value>c4</value></param>
<param><key>value</key><value>(0+0j,0+0j,0+0j)</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>c5</value></param>
<param><key>label</key><value>c5</value></param>
<param><key>value</key><value>(0+0j,0+0j,0+0j)</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>c6</value></param>
<param><key>label</key><value>c6</value></param>
<param><key>value</key><value>(0+0j,0+0j,0+0j)</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>c7</value></param>
<param><key>label</key><value>c7</value></param>
<param><key>value</key><value>(0+0j,0+0j,0+0j)</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>pad_sink_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>label</key><value>out0</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>pad_sink_1</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>label</key><value>out1</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>pad_sink_2</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>label</key><value>out2</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>pad_sink_3</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>label</key><value>out3</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>pad_sink_4</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>label</key><value>out4</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>pad_sink_5</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>label</key><value>out5</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>pad_sink_6</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>label</key><value>out6</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>pad_sink_7</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>label</key><value>out7</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>pad_sink_8</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>label</key><value>diez</value></param>
<param><key>optional</key><value>True</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>pad_sink_9</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>label</key><value>acum</value></param>
<param><key>optional</key><value>True</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>pad_sink_9_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>label</key><value>mult</value></param>
<param><key>optional</key><value>True</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>pad_sink_9_1</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>label</key><value>cod</value></param>
<param><key>optional</key><value>True</value></param>
</block>
<block>
<key>pad_source</key>
<param><key>id</key><value>pad_source_0</value></param>
<param><key>label</key><value>in</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<connection><source_block_id>b_de_ds_spreadspect_cc_0</source_block_id><sink_block_id>blocks_null_sink_0</sink_block_id><source_key>3</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>b_de_ds_spreadspect_cc_0</source_block_id><sink_block_id>blocks_null_sink_0</sink_block_id><source_key>4</source_key><sink_key>3</sink_key></connection>
<connection><source_block_id>b_de_ds_spreadspect_cc_0</source_block_id><sink_block_id>blocks_null_sink_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>b_de_ds_spreadspect_cc_0</source_block_id><sink_block_id>blocks_null_sink_0</sink_block_id><source_key>2</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>b_de_ds_spreadspect_cc_0</source_block_id><sink_block_id>pad_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>b_de_ds_spreadspect_cc_0_0</source_block_id><sink_block_id>pad_sink_9</sink_block_id><source_key>3</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>b_de_ds_spreadspect_cc_0_0</source_block_id><sink_block_id>pad_sink_9_1</sink_block_id><source_key>4</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>b_de_ds_spreadspect_cc_0_0</source_block_id><sink_block_id>pad_sink_8</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>b_de_ds_spreadspect_cc_0_0</source_block_id><sink_block_id>pad_sink_9_0</sink_block_id><source_key>2</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>b_de_ds_spreadspect_cc_0_0</source_block_id><sink_block_id>pad_sink_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>b_de_ds_spreadspect_cc_0_2</source_block_id><sink_block_id>blocks_null_sink_1</sink_block_id><source_key>3</source_key><sink_key>14</sink_key></connection>
<connection><source_block_id>b_de_ds_spreadspect_cc_0_2</source_block_id><sink_block_id>blocks_null_sink_1</sink_block_id><source_key>4</source_key><sink_key>15</sink_key></connection>
<connection><source_block_id>b_de_ds_spreadspect_cc_0_2</source_block_id><sink_block_id>blocks_null_sink_1</sink_block_id><source_key>1</source_key><sink_key>12</sink_key></connection>
<connection><source_block_id>b_de_ds_spreadspect_cc_0_2</source_block_id><sink_block_id>blocks_null_sink_1</sink_block_id><source_key>2</source_key><sink_key>13</sink_key></connection>
<connection><source_block_id>b_de_ds_spreadspect_cc_0_2</source_block_id><sink_block_id>pad_sink_7</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>b_de_ds_spreadspect_cc_0_3</source_block_id><sink_block_id>blocks_null_sink_1</sink_block_id><source_key>3</source_key><sink_key>10</sink_key></connection>
<connection><source_block_id>b_de_ds_spreadspect_cc_0_3</source_block_id><sink_block_id>blocks_null_sink_1</sink_block_id><source_key>4</source_key><sink_key>11</sink_key></connection>
<connection><source_block_id>b_de_ds_spreadspect_cc_0_3</source_block_id><sink_block_id>blocks_null_sink_1</sink_block_id><source_key>1</source_key><sink_key>8</sink_key></connection>
<connection><source_block_id>b_de_ds_spreadspect_cc_0_3</source_block_id><sink_block_id>blocks_null_sink_1</sink_block_id><source_key>2</source_key><sink_key>9</sink_key></connection>
<connection><source_block_id>b_de_ds_spreadspect_cc_0_3</source_block_id><sink_block_id>pad_sink_6</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>b_de_ds_spreadspect_cc_0_4</source_block_id><sink_block_id>blocks_null_sink_1</sink_block_id><source_key>3</source_key><sink_key>6</sink_key></connection>
<connection><source_block_id>b_de_ds_spreadspect_cc_0_4</source_block_id><sink_block_id>blocks_null_sink_1</sink_block_id><source_key>4</source_key><sink_key>7</sink_key></connection>
<connection><source_block_id>b_de_ds_spreadspect_cc_0_4</source_block_id><sink_block_id>blocks_null_sink_1</sink_block_id><source_key>1</source_key><sink_key>4</sink_key></connection>
<connection><source_block_id>b_de_ds_spreadspect_cc_0_4</source_block_id><sink_block_id>blocks_null_sink_1</sink_block_id><source_key>2</source_key><sink_key>5</sink_key></connection>
<connection><source_block_id>b_de_ds_spreadspect_cc_0_4</source_block_id><sink_block_id>pad_sink_5</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>b_de_ds_spreadspect_cc_0_5</source_block_id><sink_block_id>blocks_null_sink_1</sink_block_id><source_key>3</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>b_de_ds_spreadspect_cc_0_5</source_block_id><sink_block_id>blocks_null_sink_1</sink_block_id><source_key>4</source_key><sink_key>3</sink_key></connection>
<connection><source_block_id>b_de_ds_spreadspect_cc_0_5</source_block_id><sink_block_id>blocks_null_sink_1</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>b_de_ds_spreadspect_cc_0_5</source_block_id><sink_block_id>blocks_null_sink_1</sink_block_id><source_key>2</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>b_de_ds_spreadspect_cc_0_5</source_block_id><sink_block_id>pad_sink_4</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>b_de_ds_spreadspect_cc_0_6</source_block_id><sink_block_id>blocks_null_sink_0</sink_block_id><source_key>3</source_key><sink_key>10</sink_key></connection>
<connection><source_block_id>b_de_ds_spreadspect_cc_0_6</source_block_id><sink_block_id>blocks_null_sink_0</sink_block_id><source_key>4</source_key><sink_key>11</sink_key></connection>
<connection><source_block_id>b_de_ds_spreadspect_cc_0_6</source_block_id><sink_block_id>blocks_null_sink_0</sink_block_id><source_key>1</source_key><sink_key>8</sink_key></connection>
<connection><source_block_id>b_de_ds_spreadspect_cc_0_6</source_block_id><sink_block_id>blocks_null_sink_0</sink_block_id><source_key>2</source_key><sink_key>9</sink_key></connection>
<connection><source_block_id>b_de_ds_spreadspect_cc_0_6</source_block_id><sink_block_id>pad_sink_3</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>b_de_ds_spreadspect_cc_0_7</source_block_id><sink_block_id>blocks_null_sink_0</sink_block_id><source_key>3</source_key><sink_key>6</sink_key></connection>
<connection><source_block_id>b_de_ds_spreadspect_cc_0_7</source_block_id><sink_block_id>blocks_null_sink_0</sink_block_id><source_key>4</source_key><sink_key>7</sink_key></connection>
<connection><source_block_id>b_de_ds_spreadspect_cc_0_7</source_block_id><sink_block_id>blocks_null_sink_0</sink_block_id><source_key>1</source_key><sink_key>4</sink_key></connection>
<connection><source_block_id>b_de_ds_spreadspect_cc_0_7</source_block_id><sink_block_id>blocks_null_sink_0</sink_block_id><source_key>2</source_key><sink_key>5</sink_key></connection>
<connection><source_block_id>b_de_ds_spreadspect_cc_0_7</source_block_id><sink_block_id>pad_sink_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pad_source_0</source_block_id><sink_block_id>b_de_ds_spreadspect_cc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pad_source_0</source_block_id><sink_block_id>b_de_ds_spreadspect_cc_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pad_source_0</source_block_id><sink_block_id>b_de_ds_spreadspect_cc_0_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pad_source_0</source_block_id><sink_block_id>b_de_ds_spreadspect_cc_0_3</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pad_source_0</source_block_id><sink_block_id>b_de_ds_spreadspect_cc_0_4</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pad_source_0</source_block_id><sink_block_id>b_de_ds_spreadspect_cc_0_5</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pad_source_0</source_block_id><sink_block_id>b_de_ds_spreadspect_cc_0_6</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pad_source_0</source_block_id><sink_block_id>b_de_ds_spreadspect_cc_0_7</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
